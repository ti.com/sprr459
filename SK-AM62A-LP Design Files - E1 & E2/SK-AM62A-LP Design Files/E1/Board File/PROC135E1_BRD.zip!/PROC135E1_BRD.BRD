# Allegro board PROC135E1_BRD.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SOC_VOUT0_DATA11: length 49.6
  TOP w0.132: U18.W21 v1(45.88,111.66)
  TOP w0.14: v1(25.36,111.22) 25,111.22 24.69,111.52 U13.18
  L03_SIG01 w0.102: v1(45.88,111.66) 45.48,112.06 45.48,118.34 42.22,121.6 41.38,121.6 41.26,121.72 41.26,122.07 41.15,122.19 40.98,122.19 40.86,122.07 40.86,121.72 40.74,121.6 40.57,121.6 40.45,121.72 40.45,122.07 40.33,122.19 40.17,122.19 40.05,122.07 40.05,121.72 39.93,121.6 39.76,121.6 39.64,121.72 39.64,122.07 39.52,122.19 39.35,122.19 39.23,122.07 39.23,121.72 39.11,121.6 34.27,121.6 34.15,121.48 34.15,120.9 34.03,120.78 33.86,120.78 33.74,120.9 33.74,121.48 33.62,121.6 29.54,121.6 28.63,120.69 27.79,120.69 26.53,119.43 26.03,119.43 24.95,118.35 24.95,115.86 24.57,115.49 24.1,115.49 23.96,115.35 23.96,114.75 24.78,113.93 25.12,113.93 25.3,114.11 25.59,114.11 26.11,113.6 26.11,112.51 25.88,112.27 25.88,111.93 25.65,111.7 24.99,111.7 24.88,111.8 24.88,112.31 24.78,112.41 24.52,112.41 24.42,112.31 24.42,110.9 24.52,110.8 24.93,110.8 v1(25.36,111.22)
SOC_VOUT0_DATA12: length 48.1
  TOP w0.132: U18.W20 v1(45.88,110.86)
  TOP w0.14: v1(24.19,112.83) U13.17
  L10_SIG03 w0.102: v1(45.88,110.86) 46.28,110.46 48.31,110.46 48.49,110.65 48.49,111.03 49.14,111.67 49.14,112.17 47.98,113.33 47.98,116.38 42.13,122.23 32.59,122.23 31.69,121.34 28.51,121.34 27.51,120.34 26.18,120.34 25.63,119.79 24.02,119.79 23.63,119.4 23.63,114.36 24.14,113.85 24.14,113.41 23.91,113.18 22.83,113.18 22.73,113.08 22.73,112.88 22.83,112.78 24.15,112.78 v1(24.19,112.83)
SOC_VOUT0_DATA13: length 49.7
  TOP w0.132: U13.16 23.69,111.41 v1(23.5,111.21) ; U18.W19 v1(45.88,110.07)
  L03_SIG01 w0.102: v1(45.88,110.07) 45.59,110.07 45.48,110.17 45.48,111.11 45.64,111.26 46.14,111.26 46.28,111.4 46.28,118.43 41.83,122.87 30.02,122.87 29.51,122.37 28.87,122.37 28.75,122.25 28.75,122.02 28.63,121.9 28.46,121.9 28.34,122.02 28.34,122.25 28.22,122.37 28.05,122.37 27.93,122.25 27.93,122.02 27.81,121.9 27.65,121.9 27.53,122.02 27.53,122.25 27.41,122.37 26.98,122.37 25.21,120.6 25.21,120.14 24.71,119.64 24.34,119.64 23.3,118.6 23.3,117.77 23.42,117.65 23.58,117.65 23.7,117.53 23.7,117.36 23.58,117.24 23.42,117.24 23.3,117.12 23.3,116.95 23.42,116.83 23.58,116.83 23.7,116.72 23.7,116.55 23.58,116.43 23.42,116.43 23.3,116.31 23.3,114.51 23.97,113.84 23.97,113.32 23.7,113.05 23.7,112.36 24.05,112 24.05,110.71 23.88,110.54 23.65,110.54 23.5,110.7 v1(23.5,111.21)
SOC_VOUT0_DATA14: length 49.7
  TOP w0.132: U18.Y21 v1(46.68,111.66)
  TOP w0.14: U13.15 23.19,113.02 v1(22.56,113.65)
  L03_SIG01 w0.102: v1(22.56,113.65) 22.56,113.26 22.63,113.19 22.63,112.13 22.33,111.82 21.91,111.82 21.62,112.12 21.62,113.11 21.26,113.46 21.26,114.16 21.98,114.87 21.98,119.35 23.45,120.82 23.45,121.5 25.17,123.23 26.31,123.23 26.77,123.7 31.01,123.7 31.31,123.99 34.39,123.99 34.48,124.09 40.46,124.09 41.02,123.53 42.07,123.53 47.08,118.52 47.08,112.3 46.68,111.9 v1(46.68,111.66)
SOC_VOUT0_DATA15: length 49.5
  TOP w0.132: U18.Y22 v1(46.68,112.46)
  TOP w0.14: U13.14 v1(22.69,111.35)
  L03_SIG01 w0.102: v1(22.69,111.35) 22.96,111.61 22.96,118.78 23.08,118.9 23.08,119.15 22.78,119.46 22.78,119.62 22.9,119.74 23.08,119.74 23.37,119.44 23.54,119.44 23.66,119.56 23.66,119.73 23.35,120.04 23.35,120.2 23.47,120.32 23.65,120.32 23.99,119.98 24.54,119.98 24.87,120.3 24.87,120.68 25.14,120.95 25.14,121.12 24.46,121.8 24.46,121.97 24.58,122.09 24.74,122.09 25.42,121.41 25.59,121.41 25.71,121.53 25.71,121.7 25.02,122.39 25.02,122.54 25.15,122.67 25.32,122.67 25.95,122.03 26.1,122.03 27.33,123.27 31.4,123.27 31.49,123.18 38.52,123.18 39.13,123.79 40.27,123.79 40.84,123.21 41.95,123.21 46.68,118.48 v1(46.68,112.46)
SOC_VOUT0_DATA16: length 50.9
  TOP w0.132: v1(22.19,112.84) U13.13 ; U18.P22 v1(41.88,112.47)
  L10_SIG03 w0.102: v1(22.19,112.84) 22.62,112.42 24.42,112.42 25.81,113.81 25.81,115.11 26.29,115.59 27.21,115.59 28.79,117.17 29.17,117.17 29.29,117.05 29.29,116.63 29.41,116.51 29.57,116.51 29.69,116.63 29.69,117.05 29.81,117.17 29.98,117.17 30.1,117.05 30.1,116.63 30.22,116.51 30.39,116.51 30.51,116.63 30.51,117.05 30.63,117.17 30.79,117.17 30.91,117.05 30.91,116.63 31.03,116.51 31.2,116.51 31.32,116.63 31.32,117.05 31.44,117.17 32.25,117.17 33.04,116.38 33.04,116.21 32.91,116.09 32.91,115.92 33.03,115.8 33.2,115.8 33.33,115.92 33.49,115.92 33.74,115.68 34.62,115.68 36.68,113.63 36.68,112.9 37.48,112.09 37.48,110.7 37.25,110.47 36.84,110.47 36.68,110.3 36.68,104.28 36.91,104.05 38.91,104.05 39.11,104.26 39.11,108.6 39.11,110.4 39.38,110.67 39.38,112.47 39.75,112.84 40.14,112.84 40.32,113.02 41.71,113.02 41.88,112.85 v1(41.88,112.47)
  BOTTOM w0.14: v1(22.19,112.84) 22.19,111.07 21.59,110.47 RA3.8
SOC_VOUT0_DATA17: length 52.4
  TOP w0.132: U18.R19 v1(42.68,110.06)
  TOP w0.14: v1(21.19,112.83) U13.11
  L03_SIG01 w0.102: v1(42.68,110.06) 42.28,110.47 41.71,110.47 41.48,110.7 41.48,111.03 41.25,111.26 40.9,111.26 40.68,111.49 40.68,113.1 40.15,113.63 38.92,113.63 38.77,113.48 38.77,113.2 38.65,113.08 38.49,113.08 38.37,113.2 38.37,113.38 38.25,113.5 37.86,113.5 37.47,113.11 37.47,112.29 37.24,112.06 36.52,112.06 36.41,112.18 36.41,112.55 36.29,112.67 36.12,112.67 36,112.55 36,112.18 35.88,112.06 32.05,112.06 31.88,111.89 31.88,111.5 31.65,111.26 31.22,111.26 30.21,110.26 30.21,109.24 27.69,106.72 27,106.72 25.25,104.97 18.72,104.97 17.78,105.9 17.78,107.28 15.88,109.18 15.88,110.25 16.26,110.63 16.26,113.1 17.48,114.32 19.46,114.32 20.1,113.68 20.58,113.68 21.19,113.06 v1(21.19,112.83)
  BOTTOM w0.14: RA3.7 v1(21.19,112.83)
SOC_VOUT0_DATA18: length 51.1
  TOP w0.132: U13.10 v1(20.69,111.19) ; U18.R20 v1(42.68,110.86)
  L03_SIG01 w0.102: v1(42.68,110.86) 42.47,110.86 42.07,111.26 41.71,111.26 41.48,111.5 41.48,111.83 41.16,112.15 41.16,113.07 40.28,113.95 36.66,113.95 35.58,112.87 31.31,112.87 31.08,112.63 31.08,111.68 30.38,110.98 30.21,110.98 29.97,111.23 29.8,111.23 29.68,111.11 29.68,110.94 29.93,110.69 29.93,110.52 29.81,110.4 29.64,110.4 29.39,110.65 29.22,110.65 29.11,110.53 29.11,110.36 29.35,110.12 29.35,109.95 29.05,109.65 29.05,109.41 24.92,105.28 22.67,105.28 22.55,105.4 22.55,105.73 22.43,105.85 22.27,105.85 22.15,105.73 22.15,105.4 22.03,105.28 21.86,105.28 21.74,105.4 21.74,105.73 21.62,105.85 21.45,105.85 21.33,105.73 21.33,105.4 21.21,105.28 18.87,105.28 18.11,106.03 18.11,107.83 16.8,109.13 16.8,110.3 17.1,110.59 17.1,111.87 16.69,112.28 16.69,113.07 17.18,113.56 19.62,113.56 19.88,113.3 20.37,113.3 20.73,112.94 20.73,111.22 v1(20.69,111.19)
  BOTTOM w0.14: v1(20.69,111.19) 20.79,111.09 RA3.6
SOC_VOUT0_DATA19: length 51.9
  TOP w0.132: v1(20.19,112.84) U13.9 ; U18.R22 v1(42.68,112.46)
  L03_SIG01 w0.102: v1(20.19,112.84) 20.41,112.63 20.41,111.85 20.3,111.74 20.01,111.74 19.89,111.86 19.89,112.36 19.77,112.48 19.6,112.48 19.48,112.36 19.48,111.86 19.36,111.74 19.13,111.74 19,111.88 19,112.39 18.89,112.49 18.58,112.49 18.48,112.39 18.48,111.75 18.25,111.52 18.25,110.83 19.64,109.43 19.64,109.06 19.99,108.7 19.99,107.55 20.1,107.44 20.28,107.44 20.39,107.54 20.39,108.69 20.64,108.94 21.08,108.94 21.26,108.77 21.26,107.98 21.35,107.89 21.65,107.89 21.74,107.98 21.74,108.47 21.89,108.63 22.17,108.63 22.29,108.51 22.29,108.1 22.49,107.9 22.79,107.9 22.95,108.06 22.95,108.68 23.14,108.87 23.59,108.87 23.83,108.63 23.83,107.45 24.05,107.23 24.51,107.23 24.74,107.46 24.74,108.37 24.9,108.52 25.33,108.52 25.55,108.75 25.91,108.75 26.27,109.11 26.27,109.8 27.3,110.84 27.3,114.76 29.27,116.73 33.02,116.73 33.78,115.97 36.62,115.97 37.72,114.87 40.91,114.87 42.68,113.1 v1(42.68,112.46)
  BOTTOM w0.14: RA3.5 20.39,110.79 20.19,110.99 v1(20.19,112.84)
SOC_VOUT0_DATA20: length 50.5
  TOP w0.132: U13.8 v1(19.69,111.21) ; U18.T22 v1(43.48,112.46)
  L03_SIG01 w0.102: v1(43.48,112.46) 43.48,117.14 41.92,118.71 41.2,118.71 40.85,118.35 40.85,115.69 40.69,115.53 40.44,115.53 40.34,115.63 40.34,116.57 40.21,116.7 39.63,116.7 39.5,116.57 39.5,115.9 39.31,115.72 38.97,115.72 38.73,115.96 38.38,115.96 38.2,115.79 37.9,115.79 37.8,115.89 37.8,116.45 37.9,116.55 38.24,116.55 38.36,116.67 38.36,116.84 38.24,116.96 37.94,116.96 37.8,117.1 37.8,117.46 38,117.67 40.36,117.67 40.49,117.79 40.49,118.02 40.36,118.15 37.47,118.15 36.98,117.67 34.38,117.67 34.05,117.34 29.01,117.34 26.68,115 26.68,111.46 25.62,110.4 24.74,110.4 24.41,110.07 22.66,110.07 22.09,110.64 20.27,110.64 v1(19.69,111.21)
  BOTTOM w0.14: RA4.8 19.69,110.77 v1(19.69,111.21)
SOC_VOUT0_DATA21: length 51.9
  TOP w0.132: U18.R21 v1(42.68,111.66) ; U13.7 v1(19.19,112.84)
  L03_SIG01 w0.102: v1(42.68,111.66) 42.68,111.9 42.28,112.3 42.28,112.82 40.54,114.57 37.52,114.57 36.42,115.67 32.4,115.67 32.03,116.04 29.01,116.04 27.61,114.64 27.61,110.57 27.18,110.14 27.18,108.75 26.81,108.38 25.87,108.38 25.25,107.76 25.25,107.39 24.44,106.58 22.81,106.58 22.69,106.69 22.69,107.47 22.57,107.59 22.4,107.59 22.29,107.47 22.29,106.69 22.17,106.58 22,106.58 21.88,106.69 21.88,107.42 21.78,107.52 21.52,107.52 21.33,107.33 20.78,107.33 20.51,107.06 19.81,107.06 19.69,107.18 19.69,108.5 19.59,108.6 19.39,108.6 19.28,108.5 19.28,107.18 19.16,107.06 18.89,107.06 18.78,107.16 18.78,109.73 18.6,109.9 18.44,109.9 18.3,109.76 18.13,109.76 18.01,109.88 18.01,110.05 18.15,110.19 18.15,110.36 17.94,110.57 17.94,111.34 17.63,111.65 17.63,113.07 17.81,113.25 19.09,113.25 19.19,113.15 v1(19.19,112.84)
  BOTTOM w0.14: RA4.7 18.94,110.79 19.2,111.05 19.2,112.84 v1(19.19,112.84)
SOC_VOUT0_DATA22: length 50.4
  TOP w0.132: U18.T20 v1(43.48,110.86) ; v1(18.69,111.24) U13.6
  L03_SIG01 w0.102: v1(43.48,110.86) 43.48,111.1 43.08,111.5 43.08,112.63 43.18,112.73 43.18,113.46 43.06,113.58 42.87,113.58 42.75,113.7 42.75,113.87 42.87,113.99 43.06,113.99 43.18,114.11 43.18,114.33 43.06,114.45 42,114.45 41.89,114.57 41.89,114.74 42,114.86 43.06,114.86 43.18,114.97 43.18,115.26 43.06,115.38 41.99,115.38 41.89,115.48 41.89,115.68 41.99,115.78 43.06,115.78 43.18,115.9 43.18,116.07 43.06,116.19 41.96,116.19 41.86,116.29 41.86,116.5 41.96,116.6 43.06,116.6 43.18,116.72 43.18,117.02 42.47,117.72 41.46,117.72 41.23,117.49 41.23,115.51 40.9,115.18 37.87,115.18 36.85,116.2 36.85,116.58 36.64,116.79 33.42,116.79 33.17,117.03 29.14,117.03 26.99,114.88 26.99,111.14 25.32,109.48 24.71,109.48 24.47,109.72 22.95,109.72 22.7,109.47 21.83,109.47 21.57,109.73 20.48,109.73 18.97,111.24 v1(18.69,111.24)
  BOTTOM w0.14: v1(18.69,111.24) 18.54,111.09 18.54,110.79 RA4.6
SOC_VOUT0_DATA23: length 51.5
  TOP w0.132: U18.T21 v1(43.48,111.66) ; v1(17.5,111.2) 17.69,111.4 U13.4
  L03_SIG01 w0.102: v1(17.5,111.2) 17.5,110.46 17.18,110.14 17.18,109.3 18.48,108 18.48,106.53 18.95,106.06 20.14,106.06 20.55,106.47 21.39,106.47 21.62,106.24 25.06,106.24 26.24,107.42 26.24,107.77 26.55,108.08 26.95,108.08 28.64,109.77 28.64,111 28.9,111.26 28.9,111.54 29.05,111.69 29.32,111.69 29.47,111.84 29.47,112.11 29.63,112.26 29.9,112.26 30.6,112.97 30.6,114.62 31.1,115.12 33.08,115.12 33.54,114.65 36.66,114.65 37.05,114.26 40.4,114.26 41.48,113.18 41.48,112.3 41.71,112.07 42.02,112.07 42.02,112.06 42.05,112.06 42.28,111.83 42.28,111.5 42.51,111.26 42.85,111.26 43.08,111.03 43.08,109.9 42.85,109.67 42.46,109.67 42.28,109.49 42.28,107.39 42.41,107.26 42.96,107.26 43.08,107.39 43.08,109.43 43.31,109.66 43.65,109.66 43.88,109.9 43.88,111.08 43.48,111.48 v1(43.48,111.66)
  BOTTOM w0.14: RA4.5 18.14,110.82 17.76,111.2 v1(17.5,111.2)
SOC_VOUT0_DE: length 48.1
  TOP w0.132: U18.U17 v1(44.28,108.46)
  TOP w0.14: v1(26.44,119.93) 26.28,119.77 U13.33
  L10_SIG03 w0.102: v1(44.28,108.46) 44.68,108.86 44.68,110.23 44.91,110.46 45.33,110.46 45.48,110.62 45.48,111.05 45.7,111.26 45.75,111.26 47.75,111.26 47.88,111.39 47.88,111.9 47.71,112.07 46.41,112.07 46.28,112.2 46.28,112.77 46.38,112.87 47.57,112.87 47.68,112.97 47.68,113.16 47.54,113.29 46.42,113.29 46.28,113.43 46.28,115.77 46.37,115.86 46.5,115.86 46.61,115.75 46.61,113.72 46.7,113.63 46.84,113.63 46.92,113.71 46.92,115.53 47.02,115.64 47.17,115.64 47.27,115.53 47.27,114.75 47.38,114.64 47.54,114.64 47.65,114.74 47.65,116.23 41.96,121.92 32.78,121.92 31.82,120.96 28.64,120.96 27.62,119.93 v1(26.44,119.93)
SOC_VOUT0_HSYNC: length 48.3
  TOP w0.132: U18.T18 v1(43.48,109.26)
  TOP w0.14: v1(24.45,120.47) 24.65,120.27 U13.34
  L10_SIG03 w0.102: v1(43.48,109.26) 43.88,108.86 43.88,108.3 44.11,108.06 48.45,108.06 51.83,111.44 51.83,115.03 47.86,119 47.15,119 42.84,123.31 40.97,123.31 40.29,123.99 31.42,123.99 29.74,122.31 26.29,122.31 v1(24.45,120.47)
SOC_VOUT0_PCLK: length 1.2
  TOP w0.132: U18.AA22 v1(47.48,112.46)
  BOTTOM w0.14: R318.1 v1(47.48,112.46)
SOC_VOUT0_VSYNC: length 48.3
  TOP w0.132: U18.V17 v1(45.08,108.46)
  TOP w0.14: v1(26.3,121.02) 26.05,120.77 U13.35
  L10_SIG03 w0.102: v1(45.08,108.46) 45.48,108.86 48.6,108.86 50.39,110.65 50.39,110.82 50.07,111.13 50.07,111.3 50.19,111.42 50.36,111.42 50.67,111.11 50.84,111.11 51.41,111.68 51.41,115.02 50.12,116.31 49.95,116.31 49.53,115.89 49.36,115.89 49.24,116.01 49.24,116.18 49.66,116.6 49.66,116.77 49.54,116.89 49.37,116.89 48.95,116.47 48.79,116.47 48.67,116.59 48.67,116.76 49.08,117.18 49.08,117.34 48.97,117.46 48.8,117.46 48.38,117.04 48.21,117.04 48.09,117.16 48.09,117.33 48.51,117.75 48.51,117.92 48.39,118.04 48.22,118.04 47.8,117.62 47.64,117.62 47.52,117.74 47.52,117.91 47.93,118.33 47.93,118.49 47.73,118.69 46.86,118.69 42.65,122.9 31.47,122.9 30.58,122.01 27.28,122.01 v1(26.3,121.02)
SOC_WARM_RESETZ: length 137.2
  TOP w0.132: U18.E19 v1(33.88,110.06)
  TOP w0.14: TP87.1 39.02,16.67 40.02,17.66 v1(40.02,18.09)
  L03_SIG01 w0.102: v1(23.77,21.86) 24.25,22.34 24.25,24.38 23.01,25.62 23.01,32.91 24.09,33.99 24.09,39.88 23.29,40.68 23.29,48.75 23.78,49.24 23.78,51.24 24.21,51.67 24.21,53 22.93,54.29 22.93,56.94 17.94,61.92 17.94,65.62 17.17,66.39 17.17,67.48 16.08,68.57 14.79,68.57 13.56,69.8 13.56,73.55 10.81,76.31 10.81,82.84 13.23,85.26 13.23,88.18 14.09,89.04 15.12,89.04 16.14,90.05 17.95,90.05 18.63,90.73 18.63,95.07 19.64,96.08 19.64,99.85 20.27,100.48 22.23,100.48 24.02,102.28 24.02,102.75 24.82,103.54 25.44,103.54 27.58,105.67 29.19,105.67 29.98,106.46 33.23,106.46 33.25,106.47 33.48,106.7 33.48,107.03 33.71,107.26 34.05,107.26 34.28,107.5 34.28,107.83 34.51,108.06 34.85,108.06 35.08,108.3 35.08,110.27 34.89,110.47 34.28,110.47 v1(33.88,110.06)
  L10_SIG03 w0.102: v1(23.77,21.86) 26.68,21.86 27.16,22.34 29.03,22.34 29.77,21.6 32.49,21.6 35.52,18.57 39.54,18.57 v1(40.02,18.09)
  BOTTOM w0.14: U108.2 39.49,18.61 39.44,18.56 R534.1 v1(40.02,18.09)
SOC_WLAN_SDIO_RST: length 15.8
  TOP w0.14: U1.13 41.4,152.77 41.16,153.01 40.8,153.01 v1(40.58,152.78) ; v1(53.59,152.14) 53.59,151.82 53.34,151.56 U2.24
  L10_SIG03 w0.102: v1(40.58,152.78) 40.62,152.78 41.26,152.14 v1(53.59,152.14)
SPI0_FET_OE: length 22.6
  TOP w0.14: v1(54.52,149.06) 54.02,148.56 U2.18
  BOTTOM w0.14: v1(54.52,149.06) 54.52,148.72 55.81,147.43 55.81,145.63 55.53,145.34 55.53,145.11 55.53,145.1 55.53,144.87 55.53,144.87 55.53,142.88 55.53,142.4 56.68,141.24 58.68,141.24 60.46,139.47 R284.2 U55.15
SPI0_FET_SEL: length 18.5
  TOP w0.14: U2.17 53.6,148.06 53.81,147.85 R13.1 R14.2 v1(53.21,146.58)
  L03_SIG01 w0.102: v1(53.21,146.58) 51.98,145.35 51.98,141.91 53.98,139.91 53.98,135.55 v1(54.35,135.18)
  BOTTOM w0.14: U55.1 53.67,134.49 v1(54.35,135.18)
SPI_HOLDN: length 1.6
  TOP w0.14: U34.7 56.89,61.22 R145.2
SPI_WPN: length 1.5
  TOP w0.14: U34.3 64.57,62.49 64.75,62.67 R142.2
SS_LM5141: length 1.9
  BOTTOM w0.14: C429.1 33.6,42.59 34.03,43.02 U89.22
SW_2V5: length 3.7
  BOTTOM w0.305: L9.1 U81.5
SW_LM5141: length 6.5
  BOTTOM w0.254: 35.97,49.39 35.53,48.95 U89.12 ; C412.1 38.8,50.56
  vias: v1(41.82,48.38) v1(41.82,47.42) v1(42.79,53.21) v1(42.79,52.24) v1(42.79,51.28) v1(42.79,50.31) v1(42.79,49.35) v1(42.79,48.38) v1(42.79,47.42) v1(43.76,53.21) v1(43.76,52.24) v1(43.76,51.28) v1(43.76,50.31) v1(43.76,49.35) v1(43.76,48.38) v1(43.76,47.42) v1(44.72,53.21) v1(44.72,52.24) v1(44.72,51.28) v1(44.72,50.31) v1(44.72,49.35) v1(44.72,48.38) v1(44.72,47.42)
SYS_BOOTMODE0: length 17.4
  TOP w0.14: v1(41.01,36.28) SW2.1
  L05_SIG02 w0.102: v1(41.22,28.99) 41.73,28.99 43.41,30.67 44.91,30.67 45.34,31.1 45.34,32.98 42.04,36.28 v1(41.01,36.28)
  BOTTOM w0.14: U100.1 v1(41.22,28.99) U101.10 ; R455.1 v1(41.01,36.28)
SYS_BOOTMODE1: length 17.3
  TOP w0.14: v1(39.74,36.28) SW2.2
  L05_SIG02 w0.102: v1(40.38,29.49) 41.34,29.49 43.54,31.69 44.12,31.69 44.43,31.99 44.43,33.49 42.09,35.83 40.19,35.83 v1(39.74,36.28)
  BOTTOM w0.14: U101.9 v1(40.38,29.49) U100.2 ; R456.1 v1(39.74,36.28)
SYS_BOOTMODE2: length 15.8
  TOP w0.14: v1(38.47,36.28) SW2.3
  L05_SIG02 w0.102: v1(41.22,29.99) 43.54,32.31 43.54,34 41.96,35.57 39.18,35.57 v1(38.47,36.28)
  BOTTOM w0.14: U100.3 v1(41.22,29.99) U101.8 ; R457.1 v1(38.47,36.28)
SYS_BOOTMODE3: length 17
  TOP w0.14: v1(37.2,36.28) SW2.4
  L05_SIG02 w0.102: v1(37.2,36.28) 38.21,35.27 41.84,35.27 43.21,33.9 43.21,32.37 41.35,30.52 40.41,30.52 v1(40.38,30.49)
  BOTTOM w0.14: U101.7 v1(40.38,30.49) U100.4 ; R458.1 v1(37.2,36.28)
SYS_BOOTMODE4: length 16.3
  TOP w0.14: v1(35.93,36.28) SW2.5
  L05_SIG02 w0.102: v1(35.93,36.28) 35.93,36.27 37.19,35.01 41.67,35.01 42.85,33.83 42.85,32.62 v1(41.22,30.99)
  BOTTOM w0.14: U101.6 v1(41.22,30.99) U100.5 ; R459.1 v1(35.93,36.28)
SYS_BOOTMODE5: length 16.6
  TOP w0.14: v1(34.66,36.28) SW2.6
  L05_SIG02 w0.102: v1(34.66,36.28) 36.21,34.74 41.23,34.74 41.73,34.23 41.73,31.96 41.26,31.49 v1(40.38,31.49)
  BOTTOM w0.14: U100.6 v1(40.38,31.49) U101.5 ; R460.1 v1(34.66,36.28)
SYS_BOOTMODE6: length 15
  TOP w0.14: v1(33.39,36.28) SW2.7
  L05_SIG02 w0.102: v1(41.22,31.99) 41.22,32.81 40.31,33.72 35.95,33.72 v1(33.39,36.28)
  BOTTOM w0.14: R461.1 v1(33.39,36.28) ; U100.7 v1(41.22,31.99) U101.4
SYS_BOOTMODE7: length 14.7
  TOP w0.14: v1(32.12,36.28) SW2.8
  L05_SIG02 w0.102: v1(32.12,36.28) 35.03,33.38 39.5,33.38 v1(40.38,32.49)
  BOTTOM w0.14: U100.8 v1(40.38,32.49) U101.3 ; R462.1 v1(32.12,36.28)
SYS_BOOTMODE8: length 19
  TOP w0.14: R192.1 v1(54.47,36.28) SW3.1
  BOTTOM w0.14: U98.10 51.57,33.15 51.35,33.38 51.35,33.84 49.31,35.87 ; v1(54.47,36.28) 54.06,35.87 49.31,35.87 ; U100.9 43.63,34.1 45.4,35.87 49.31,35.87
SYS_BOOTMODE9: length 17.3
  TOP w0.14: SW3.2 v1(53.2,36.28) R191.1
  L03_SIG01 w0.102: v1(53.2,36.28) 52.61,35.69 52.61,33.32 v1(51.95,32.65)
  BOTTOM w0.14: U100.10 44.13,34.05 45.65,35.57 49.16,35.57 50.98,33.75 50.98,33.22 51.55,32.65 v1(51.95,32.65) U98.9
SYS_BOOTMODE10: length 17.3
  TOP w0.14: R190.1 v1(51.93,36.28) SW3.3
  L03_SIG01 w0.102: v1(51.93,36.28) 51.11,35.46 v1(51.11,32.15)
  BOTTOM w0.14: U100.11 44.63,34.01 45.89,35.27 49.03,35.27 50.68,33.63 50.68,32.59 v1(51.11,32.15) U98.8
SYS_BOOTMODE11: length 18.2
  TOP w0.14: R189.1 v1(50.66,36.28) SW3.4
  L03_SIG01 w0.102: v1(51.95,31.65) 51.94,31.66 51.03,31.66 50.66,32.03 v1(50.66,36.28)
  BOTTOM w0.14: U100.12 45.13,34.08 46.01,34.96 48.88,34.96 50.28,33.56 50.28,32.3 50.92,31.65 v1(51.95,31.65) U98.7
SYS_BOOTMODE12: length 17.8
  TOP w0.14: SW3.5 v1(49.39,36.28) R188.1
  L03_SIG01 w0.102: v1(51.11,31.15) 49.39,32.87 v1(49.39,36.28)
  BOTTOM w0.14: U98.6 v1(51.11,31.15) 50.83,31.15 49.97,32.02 49.97,33.4 48.73,34.63 46.27,34.63 45.63,33.99 U100.13
SYS_BOOTMODE13: length 19.2
  TOP w0.14: SW3.6 v1(48.12,36.28) R187.1
  L03_SIG01 w0.102: v1(51.95,30.65) 51.92,30.68 50.92,30.68 48.12,33.47 v1(48.12,36.28)
  BOTTOM w0.14: U100.14 46.13,33.98 46.42,34.27 48.6,34.27 49.67,33.21 49.67,31.74 50.76,30.65 v1(51.95,30.65) U98.5
SYS_BOOTMODE14: length 19
  TOP w0.14: R186.1 v1(46.85,36.28) SW3.7
  L03_SIG01 w0.102: v1(51.11,30.15) 50.66,30.15 46.85,33.96 v1(46.85,36.28)
  BOTTOM w0.14: U98.4 v1(51.11,30.15) 50.7,30.15 49.34,31.51 49.34,33.11 48.48,33.97 46.82,33.97 46.63,33.77 U100.15
SYS_BOOTMODE15: length 20.2
  TOP w0.14: SW3.8 v1(45.58,36.28) R185.1
  L03_SIG01 w0.102: v1(51.95,29.65) 50.63,29.65 45.58,34.71 v1(45.58,36.28)
  BOTTOM w0.14: U100.16 47.13,33.54 47.26,33.66 48.32,33.66 49.03,32.95 49.03,31.36 50.69,29.71 51.89,29.71 v1(51.95,29.65) U98.3
SYSBOOT_BUF_ENZ: length 30.2
  TOP w0.132: v1(69.68,29.04) U45.1
  TOP w0.14: R170.1 R171.1 60.57,46.6 60.71,46.74 61.66,46.74 62.26,46.14 v1(62.26,45.79)
  L03_SIG01 w0.102: v1(62.26,45.79) 62.26,44.11 61.11,42.97 61.11,41.11 61.85,40.37 61.85,36.87 60.91,35.93 60.91,30.9 61.78,30.04 63.68,30.04 63.96,30.32 68.41,30.32 v1(69.68,29.04)
TCA6424_EXP_INT: length 2
  BOTTOM w0.14: U100.32 43.63,27.6 43.45,27.42 42.7,27.42 R490.1
TEMP_DIODE_P: length 11.2
  TOP w0.132: U18.F10 v1(34.68,102.07)
  BOTTOM w0.14: TP99.1 28.93,104.09 30.24,102.79 30.24,101.86 30.43,101.67 34.05,101.67 34.45,102.07 v1(34.68,102.07)
TEST_GPIO1: length 40.1
  L03_SIG01 w0.102: v1(59.01,16.41) 59.01,17.05 58.63,17.43 58.63,18.97 59.18,19.51 59.18,21.65 59.89,22.35 59.89,23.84 60.77,24.73 60.77,25.36 61.97,26.56 61.97,27.17 62.65,27.85 62.98,27.85 64.64,29.51 v1(64.95,29.51)
  L05_SIG02 w0.102: v1(42.6,18.59) 43.14,18.59 45.6,16.13 49.24,16.13 49.77,16.66 51.26,16.66 51.7,16.22 58.82,16.22 v1(59.01,16.41)
  BOTTOM w0.14: R484.1 64.83,27.52 64.95,27.63 v1(64.95,29.51) ; v1(42.6,18.59) 43.21,18.59 43.47,18.85 Q13.1 ; R548.1 60.07,16.38 59.86,16.17 R556.1 59.26,16.17 v1(59.01,16.41)
TEST_GPIO2: length 39.5
  L03_SIG01 w0.102: v1(59.39,19.14) 59.72,18.8 59.72,16.03 59.36,15.66 58.24,15.66 57.65,16.26 57.65,19.87 57.97,20.19 57.97,22.62 57.24,23.35 57.24,24.97 58.24,25.97 58.24,27.32 58.86,27.94 v1(58.86,29.52) 59.63,30.28 59.63,33.73 60.48,34.58 60.48,39.46 58.29,41.65 58.29,43.63 v1(57.8,44.11)
  BOTTOM w0.14: U92.18 v1(57.8,44.11) ; R533.1 58.42,18.63 R531.1 59.23,18.98 v1(59.39,19.14) ; v1(58.86,29.52) R481.1
TEST_GPIO3: length 42.9
  TOP w0.132: v1(79.84,27.55) 79.55,27.55 79.41,27.69 TP76.1 75.65,27.69 73.87,29.47 71.64,29.47 v1(71.21,29.04) 71.21,27.69 70.82,27.31 U45.2
  L03_SIG01 w0.102: v1(58.08,17.02) 58.08,19.75 58.91,20.57 58.91,26.11 62.48,29.69 64.22,29.69 64.47,29.93 65.46,29.93 v1(65.91,29.48) 67.67,29.48 68.56,28.58 70.75,28.58 v1(71.21,29.04)
  BOTTOM w0.14: J16.1 R486.1 v1(79.84,27.55) ; R483.1 65.72,27.52 65.91,27.71 v1(65.91,29.48) ; v1(58.08,17.02) 57.25,16.19 R557.1
TEST_GPIO4: length 44.9
  TOP w0.14: TP75.1 67.53,28.86 v1(67.31,28.63)
  L03_SIG01 w0.102: v1(56.77,18.89) 57.24,18.42 57.24,16.17 58.03,15.38 59.47,15.38 60.05,15.96 60.05,21.53 60.73,22.21 60.73,22.77 66.04,28.08 66.75,28.08 v1(67.31,28.63)
  BOTTOM w0.14: R482.1 67.08,28.41 v1(67.31,28.63) ; U100.28 45.63,26.57 45.99,26.2 46.46,26.2 46.95,26.69 51.86,26.69 54.98,23.57 54.98,19.73 56.46,18.25 R536.1 57.07,18.59 v1(56.77,18.89) 57.09,19.2 R527.1
TEST_PORZN: length 45.7
  L03_SIG01 w0.102: v1(57.85,35.85) 56.34,34.34 56.34,29.63 58.01,27.96 58.01,26.06 57.01,25.06 57.01,23.15 57.74,22.42 57.74,20.42 56.38,19.05 56.38,15.92 57.53,14.77 61.13,14.77 v1(63.29,16.93)
  L05_SIG02 w0.102: v1(67.16,32.89) 66.92,33.14 63.17,33.14 62.05,34.25 59.41,34.25 57.85,35.82 v1(57.85,35.85)
  BOTTOM w0.14: R472.1 66.06,33.11 66.28,32.89 v1(67.16,32.89) ; U96.6 57.71,35.99 v1(57.85,35.85) ; v1(63.29,16.93) 62.93,16.93 62.78,16.78 R547.1 62.45,16.38 62.24,16.17 R555.1
TEST_POWERDOWN: length 106
  TOP w0.14: R201.1 26.89,33.86 v1(27.08,34.05) ; U36.6 v1(19.68,57.29) ; R194.1 64.21,35.62 63.87,35.28 v1(63.64,35.28)
  L03_SIG01 w0.102: v1(21.64,36.65) 21.64,41.51 21.42,41.73 21.42,48.39 22.3,49.26 22.3,51.9 22.81,52.41 22.81,53.18 19.68,56.31 v1(19.68,57.29) ; v1(63.64,35.28) 62.4,35.28 61.17,34.05 61.17,31.13 62,30.29 63.25,30.29 63.6,30.65 69.4,30.65 69.75,30.29 71.05,30.29 71.78,29.55 71.78,25.51 70.23,23.96 70.23,21.89 68.94,20.6 68.21,20.6 64.97,17.36 v1(64.97,16.93)
  L10_SIG03 w0.102: v1(21.64,36.65) 21.89,36.65 22.85,35.68 26.31,35.68 27.08,34.91 v1(27.08,34.05) 27.18,33.95 28.01,33.95 28.33,34.28 30.46,34.28 32.13,32.6 33.84,32.6 34.66,33.43 40.23,33.43 40.98,34.18 56.06,34.18 56.66,33.58 62.52,33.58 63.64,34.69 v1(63.64,35.28)
  BOTTOM w0.14: v1(64.97,16.93) R546.1 64.64,16.38 64.43,16.17 R554.1
TEST_WARMRESETN: length 55.1
  TOP w0.14: R198.1 67.63,35.26 68.15,34.74 v1(68.15,34.28)
  L05_SIG02 w0.102: v1(37.65,19.75) 43.44,19.75 46.52,16.66 49.19,16.66 49.63,17.1 56.91,17.1 58.18,18.38 60.61,18.38 v1(61.41,19.18)
  L10_SIG03 w0.102: v1(68.15,34.28) 68.15,31.36 70.16,29.35 70.16,21.02 68.32,19.18 v1(61.41,19.18)
  BOTTOM w0.14: v1(61.41,19.18) R530.1 60.95,18.63 60.74,18.41 R532.1 ; v1(37.65,19.75) 37.63,19.75 37.62,19.74 Q14.1
TM4C129_TCK: length 2.7
  TOP w0.132: TP85.1 53.43,21.1 53.51,21.03 U47.100
TM4C129_TDI: length 2.4
  TOP w0.14: U47.98 53.39,21.83 TP83.1
TM4C129_TDO: length 2.6
  TOP w0.14: TP82.1 52.99,23.39 53.01,23.37 53.01,23.01 53.8,22.23 U47.97
TM4C129_TMS: length 1.8
  TOP w0.14: TP84.1 53.04,21.43 U47.99
TMP1_ADD0: length 3.2
  TOP w0.14: U16.5 19.15,105.55 18.46,106.24 R64.1
TMP1_ADD1: length 1.2
  TOP w0.14: R63.1 U16.3
TMP2_ADD1: length 1.4
  TOP w0.14: U29.3 R129.1
TPS6593_EN: length 2.2
  TOP w0.14: R148.1 21.13,55.75 U36.4
UART1_FET_BUF_EN: length 54.1
  TOP w0.14: U40.2 v1(51.93,49.57) ; U54.1 22.42,37.4 22.24,37.22 21.96,37.22 21.82,37.36 U54.16 21.4,37.81 21.3,37.71 R263.1 20.93,37.43 20.93,36.73 20.79,36.59 19.87,36.59 v1(19.83,36.62)
  L10_SIG03 w0.102: v1(25.29,42.85) 26.23,42.85 26.95,43.58 29.33,43.58 29.7,43.95 29.7,44.19 31.27,45.76 32,45.76 32.18,45.94 32.18,46.52 32.97,47.31 37.09,47.31 37.55,47.78 38.68,47.78 39.12,47.34 39.54,47.34 39.79,47.09 39.79,46.6 40.06,46.34 47.27,46.34 47.52,46.58 48.58,46.58 51.57,49.57 v1(51.93,49.57)
  BOTTOM w0.14: U92.11 53.7,47.8 v1(51.93,49.57) ; v1(19.83,36.62) 20.43,36.62 20.83,36.22 21.94,36.22 22.08,36.36 22.08,38.15 23.45,39.52 23.45,41.2 23.9,41.65 24.87,41.65 25.03,41.49 25.57,41.49 25.77,41.69 25.77,42.37 v1(25.29,42.85)
UART1_FET_BUF_EN_INV: length 34.9
  TOP w0.14: U40.4 52.58,50.56 53.34,49.8 53.34,48.1 52.94,47.69 v1(52.5,47.69)
  L10_SIG03 w0.102: v1(52.5,47.69) 52.05,47.23 52.05,46.1 51.5,45.55 51.5,44.62 50.64,43.77 49.13,43.77 47.74,45.16 37.76,45.16 37.18,44.58 36.57,44.58 35,43.01 35,42.5 v1(31.78,39.28)
  BOTTOM w0.14: U95.15 31.3,36.78 31.47,36.95 31.47,37.51 31.89,37.93 31.89,39.17 v1(31.78,39.28)
UART1_FET_SEL: length 39.5
  TOP w0.14: v1(57.8,42.11) R177.2 R179.1
  L10_SIG03 w0.102: v1(27.83,37.33) 28.45,36.71 37.7,36.71 38.98,38 38.98,38.69 40.82,40.53 50.19,40.53 51.59,41.93 57.62,41.93 v1(57.8,42.11)
  BOTTOM w0.14: v1(27.83,37.33) 27.83,36.93 27.02,36.13 U95.1 ; R177.2 v1(57.8,42.11)
UART_SHIELD:
  vias: v1(1.38,18.4) v1(1.38,16.88) v1(1.38,15.36) v1(2.91,18.4) v1(2.91,16.88) v1(2.91,15.36)
USB_DM: length 1.9
  TOP w0.132: v1(3.91,135.65) 3.77,135.65 3.66,135.54 J2.5
  BOTTOM w0.14: TP97.1 3.77,135.72 3.83,135.65 v1(3.91,135.65)
USB_DP: length 1.9
  TOP w0.132: J2.3 3.66,135.04 3.77,134.94 v1(3.91,134.94)
  BOTTOM w0.14: v1(3.91,134.94) 3.84,134.87 TP98.1
USB_TYPEA_EARTH:
  vias: v1(79.18,66.48) v1(80.04,66.48) v1(80.44,74.84) v1(80.44,73.32) v1(80.44,71.79) v1(80.44,70.27) v1(80.96,67.32) v1(81.82,67.32) v1(81.97,74.84) v1(81.97,73.32) v1(81.97,71.79) v1(81.97,70.27) v1(82.68,67.32) v1(83.19,66.56) v1(83.19,65.7) v1(83.49,74.84) v1(83.49,73.32) v1(83.49,71.79) v1(83.49,70.27)
USB_TYPEACONN_DM: length 8.5
  TOP w0.102: J7.2 70.33,71.3 69.44,72.2 68.47,72.2 68.1,71.83 U30.5 67.59,71.83 67.26,72.17 66.72,72.17 66.38,72.5 66.38,74.47 66.07,74.79 L4.2
USB_TYPEACONN_DP: length 8.1
  TOP w0.102: J7.3 70.34,73.3 69.45,72.41 68.46,72.41 68.09,72.78 U30.6 67.6,72.78 67.2,72.38 66.81,72.38 66.59,72.59 66.59,74.45 66.92,74.77 L4.3
USB_TYPEC1_EARTH:
  vias: v1(1.37,46.57) v1(1.37,45.05) v1(1.37,43.52) v1(2.9,46.57) v1(2.9,45.05) v1(2.9,43.52) v1(4.14,51.84) v1(4.14,50.92) v1(5.06,51.84) v1(5.06,50.92) v1(5.97,51.84) v1(5.97,50.92)
USB_TYPEC2_EARTH:
  vias: v1(1.37,31.57) v1(1.37,30.05) v1(1.37,28.52) v1(2.9,31.57) v1(2.9,30.05) v1(2.9,28.52) v1(4.14,36.9) v1(4.14,35.99) v1(5.06,36.9) v1(5.06,35.99) v1(5.97,36.9) v1(5.97,35.99)
USBC_CONN1_CC1: length 21.4
  TOP w0.14: C113.1 21.79,50.41 v1(21.78,50.4) ; v1(10.08,46.33) D4.1 9.07,45.95 J13.A5
  L10_SIG03 w0.102: v1(21.78,50.4) 21.38,50.8 19.44,50.8 18.48,51.76 15.22,51.76 14.65,51.19 14.64,51.19 14.42,50.97 14.42,50.96 13.97,50.52 13.97,47.57 12.73,46.33 v1(10.08,46.33)
  BOTTOM w0.14: U90.24 21.38,49 21.3,49.09 21.3,49.92 v1(21.78,50.4)
USBC_CONN1_CC2: length 28.1
  TOP w0.14: J13.B5 5.52,44.2 v1(5.35,44.36) ; v1(22.69,50.4) 22.53,50.24 C116.1
  L10_SIG03 w0.102: v1(22.69,50.4) 21.76,51.34 21.76,51.75 21.26,52.25 14.98,52.25 13.66,50.93 13.66,48.19 13.32,47.85 9.29,47.85 7.83,46.39 7.83,45.89 6.3,44.36 v1(5.35,44.36)
  BOTTOM w0.14: U90.26 22.18,49.06 22.31,49.2 22.31,50.02 v1(22.69,50.4) ; D10.1 5.14,44.58 v1(5.35,44.36)
USBC_CONN2_CC1: length 21.2
  TOP w0.14: v1(9.55,32.1) D5.1 9.01,30.95 J15.A5 ; C131.1 v1(22.18,40.88)
  L05_SIG02 w0.102: v1(9.55,32.1) 13.28,35.84 17.98,35.84 18.49,36.35 18.49,37.77 20.98,40.26 21.56,40.26 v1(22.18,40.88)
  BOTTOM w0.14: U90.45 v1(22.18,40.88)
USBC_CONN2_CC2: length 28.4
  TOP w0.14: v1(4.65,28.23) 4.65,28.44 5.41,29.2 J15.B5 ; C130.1 v1(21.12,40.88)
  L05_SIG02 w0.102: v1(4.65,28.23) 5,27.87 7.18,27.87 9.12,29.82 9.12,32.67 12.62,36.17 15.96,36.17 16.83,37.04 17.68,37.04 18.25,37.61 18.25,38.01 v1(21.12,40.88)
  BOTTOM w0.14: v1(4.65,28.23) 4.85,28.02 D11.1 ; v1(21.12,40.88) 21.38,41.14 U90.47
USBC_CONN2_DM: length 12.3
  TOP w0.102: v1(7.07,29.59) 7.36,29.59 7.5,29.45 J15.A7 8.17,29.45 8.56,29.84 9.65,29.84 D6.3 10.05,29.61 10.12,29.53 10.8,29.53 11.11,29.84 12.09,29.84 12.41,29.52 L7.3 ; J15.B7 5.79,30.2 5.64,30.05 5.36,30.05 5.11,30.3 v1(5.11,30.41)
  L10_SIG03 w0.102: v1(5.11,30.41) 5.28,30.23 5.8,30.23 6.46,30.89 7.53,30.89 7.85,30.56 7.85,30.08 7.53,29.76 7.25,29.76 v1(7.07,29.59)
USBC_CONN2_DP: length 12.3
  TOP w0.102: J15.B6 5.79,29.7 5.65,29.84 5.35,29.84 v1(5.11,29.59) ; L7.2 12.4,30.37 12.08,30.05 11.11,30.05 10.8,30.36 10.12,30.36 10.05,30.29 D6.2 9.65,30.05 8.58,30.05 8.19,30.45 J15.A6 7.5,30.45 7.35,30.3 v1(7.07,30.3)
  L10_SIG03 w0.102: v1(7.07,30.3) 7.07,30.07 7.18,29.97 7.45,29.97 7.65,30.17 7.65,30.48 7.44,30.68 6.54,30.68 5.88,30.02 5.03,30.02 4.93,29.92 4.93,29.77 v1(5.11,29.59)
VHDMI_AVCC_1V2: length 6
  TOP w0.254: v1(14.68,118.77) U13.60 ; v1(14.68,115.77) U13.66
  BOTTOM w0.254: C203.1 v1(14.68,118.77) ; C207.1 v1(14.68,115.77)
  BOTTOM w0.381: v1(14.68,118.77) 13.97,118.77 13.85,118.65 FB2.1 13.74,117.9 13.85,117.79 13.85,117.71 14.29,117.27 C205.1
VHDMI_CVCC_1V2: length 9
  TOP w0.254: U13.47 v1(19.69,121.12) ; v1(17.01,121.01) 16.96,121.01 16.69,121.28 U13.53 ; U13.42 22.19,121.12 22.2,121.12 v1(22.2,121.02) ; U13.12 v1(21.69,111.25) ; U13.26 24.67,116.27 v1(24.41,116.02) ; U13.5 v1(18.19,112.82)
  BOTTOM w0.254: v1(17.01,121.01) 17.01,120.54 C200.1 ; C201.1 v1(22.2,121.02) ; v1(24.41,116.02) C206.1 ; C196.1 19.59,121.22 v1(19.69,121.12) ; C212.1 v1(21.69,111.25) ; C208.1 v1(18.19,112.82)
  vias: v1(16.69,123.76) v1(16.69,122.85)
VHDMI_IOVCC_3V3: length 10.5
  TOP w0.254: v1(14.3,109.82) 14.3,110.28 14.39,110.37 R57.1 ; U13.21 26.05,113.77 v1(26.3,114.02) ; v1(17.8,124.61) 17.51,124.32 R45.1 ; v1(20.66,121.09) 20.45,121.09 20.19,121.35 U13.46 ; U13.3 v1(17.19,112.82)
  L06_PWR01 w0.381: 17.45,124.96 v1(17.8,124.61) 18.75,124.61
  L06_PWR01 w0.406: v1(20.66,121.09) 20.66,121.68 20.78,121.81
  BOTTOM w0.254: v1(17.8,124.61) 17.85,124.61 17.88,124.57 R298.1 ; C211.1 26.17,113.89 v1(26.3,114.02) ; v1(17.19,112.82) 17.05,112.68 C210.1 ; C197.1 20.66,121.5 v1(20.66,121.09) 20.75,121 R310.1
  vias: v1(13.44,109.82)
VLDO_CSI_1V8: length 1.6
  BOTTOM w0.305: U50.5 58.54,149.15 58.37,149.32 R248.1
VLDO_CSI_3V3: length 1.8
  BOTTOM w0.305: U50.6 59.04,149.22 R247.1
VMAIN: length 5.5
  TOP w0.254: R199.1 v1(26.17,34.06)
  BOTTOM w0.254: v1(38.47,46.03) 38.37,45.92 C420.1 36.75,45.92 36.69,45.86 U89.15 ; v1(32.63,39.49) 32.08,40.03 R444.2
  BOTTOM w0.305: U120.2 C505.1
  vias: v1(15.19,47.09) v1(15.19,46.63) v1(15.65,47.09) v1(15.65,46.63) v1(15.65,42.45) v1(15.65,41.99) v1(15.65,41.53) v1(15.65,41.08) v1(16.1,47.09) v1(16.1,46.63) v1(16.1,42.45) v1(16.1,41.99) v1(16.1,41.53) v1(16.1,41.08) v1(26.82,31.79) v1(27.78,31.79) v1(28.75,33.49) v1(28.75,32.7) v1(28.75,31.79) v1(29.71,33.49) v1(29.71,32.7) v1(29.71,31.79) v1(38.27,48.76) v1(38.93,44.52) v1(38.93,43.55) v1(38.93,42.59) v1(38.93,41.62) v1(39.23,48.76) v1(39.23,47.8) v1(39.23,46.83) v1(39.89,44.52) v1(39.89,43.55) v1(39.89,42.59) v1(39.89,41.62) v1(40.2,48.76) v1(40.2,47.8) v1(40.2,46.83) v1(45.58,7.53) v1(46.5,7.53)
VPHY_3V3_FT4232: length 3.3
  TOP w0.254: U48.4 v1(18.01,16.71)
  BOTTOM w0.254: v1(18.01,16.71) 18.26,16.97 C486.2 FL14.1
VPLL_3V3_FT4232: length 9.1
  TOP w0.254: R235.2 13.65,10.27 13.42,10.5 13.42,12.61 15.03,14.21 v1(15.69,14.21) U48.9
  BOTTOM w0.254: FL15.1 14.91,14.18 C494.2 v1(15.69,14.21)
VPP_1V8: length 8.4
  TOP w0.254: C81.1 23.57,82.84 TP35.1
  TOP w0.305: C81.1 v1(22.73,82.04) 22.23,81.54 U27.11
  TOP w0.356: U18.F7 v1(34.68,99.67)
  L06_PWR01 w0.457: v1(22.73,82.04) 23.44,82.04
  L08_PWR03 w0.305: 34.31,99.29 v1(34.68,99.67) 35.03,99.31
  BOTTOM w0.254: C288.1 29.19,99.73 28.99,99.53 v1(28.99,99.51) C291.1
  BOTTOM w0.305: v1(34.68,99.67) 34.48,99.46 C290.1
VPP_EN: length 75.3
  TOP w0.132: U27.19 v1(18.24,84.54)
  L05_SIG02 w0.102: v1(49.29,42.23) 48.95,42.23 46.9,44.27 46.8,44.27 46.02,45.06 46.02,54.32 43.65,56.68 43.65,58.99 42.19,60.45 36.26,60.45 35.14,59.34 19.6,59.34 17.92,61.01 17.92,66.73 18.15,66.96 18.15,67.99 18.62,68.46 18.62,74.13 19.23,74.74 19.23,76.58 18.9,76.91 18.9,82.59 18.74,82.75 18.43,82.75 18.24,82.95 v1(18.24,84.54)
  BOTTOM w0.14: U92.5 50.22,43.11 49.34,42.23 v1(49.29,42.23)
VRTC_PMIC_1V8: length 2.8
  TOP w0.305: U27.3 22.36,77.54 TP37.1 22.82,77.09 C86.1
VSEL_SD_SOC: length 59.7
  TOP w0.132: v1(16.24,83.17) U27.23
  TOP w0.14: v1(39.97,113.24) 39.99,113.26 40.29,113.26 40.89,112.66 40.89,112.28 U18.N22 ; TP19.1 14.37,100.9 v1(14.28,100.8) 13.99,101.09 R87.1
  L03_SIG01 w0.102: v1(14.28,100.8) 14.06,101.02 14.06,102.06 14.94,102.94 19.25,102.94 19.89,103.58 21.25,103.58 21.9,104.23 25.33,104.23 27.25,106.15 28.09,106.15 30,108.06 33.29,108.06 33.48,108.25 33.48,109.44 33.25,109.67 32.45,109.67 32.06,109.67 31.88,109.84 31.88,111.08 32.06,111.26 38.91,111.26 39.5,111.86 39.5,112.78 v1(39.97,113.24)
  L10_SIG03 w0.102: v1(16.24,83.17) 15.22,84.19 15.22,88.53 15.65,88.96 15.65,95.73 15.15,96.23 15.15,99.93 v1(14.28,100.8)
WKUP_LFOSCO_XI: length 7.8
  TOP w0.14: U18.A8 30.48,100.26 30.25,100.04 27.84,100.04 27.52,99.72 27.52,99.19 27.21,98.87 C45.1 24.74,98.87 Y2.1
WKUP_LFOSCO_XO: length 7
  TOP w0.14: Y2.2 24.74,101.77 C42.1 27.21,101.77 27.71,101.27 30.69,101.27 U18.A9
WKUP_UART0_CTS_3V3: length 96
  TOP w0.132: U18.C10 v1(32.28,102.07)
  L03_SIG01 w0.102: v1(32.28,102.07) 31.88,101.67 31.3,101.67 29.57,99.93 29.57,99.48 27.56,97.47 27.56,95.07 26.93,94.43 26.93,84.37 23.55,80.99 23.55,71.08 22.94,70.48 22.94,66.57 23.23,66.28 23.23,61.06 23.93,60.36 23.93,54.37 24.72,53.58 24.72,51.6 24.23,51.11 24.23,50.51 24.6,50.14 24.6,49.15 24.41,48.96 24.41,48.27 23.55,47.41 23.55,40.8 24.35,40 24.35,33.8 23.87,33.32 23.87,25.26 24.51,24.62 24.51,17.01 25.28,16.24 26.78,16.24 v1(26.8,16.27)
  BOTTOM w0.14: v1(26.8,16.27) 26.8,15.66 26.71,15.57 U118.9
WKUP_UART0_RTS_3V3: length 91
  TOP w0.132: U18.C8 v1(32.28,100.47)
  L03_SIG01 w0.102: v1(32.28,100.47) 32.08,100.47 31.68,100.07 30.48,100.07 30.03,99.61 30.03,99.25 28.02,97.24 28.02,94.88 27.38,94.24 27.38,83.33 28.9,81.81 28.9,76.1 28.17,75.38 28.17,61.28 27.13,60.24 27.13,51.14 26.19,50.2 26.19,48.2 24.02,46.03 24.02,41 24.94,40.08 24.94,25.28 25.12,25.1 25.12,18.39 v1(25.64,17.87)
  BOTTOM w0.14: v1(25.64,17.87) U118.7
WKUP_UART0_RX_3V3: length 92.3
  TOP w0.132: U18.C9 v1(32.28,101.27)
  L03_SIG01 w0.102: v1(26.24,17.13) 25.71,17.13 24.79,18.05 24.79,24.87 24.1,25.56 24.1,33.15 24.64,33.69 24.64,40.06 23.78,40.92 23.78,46.85 25.29,48.37 25.29,50.95 26.04,51.7 26.04,58.76 25.71,59.09 25.71,66.92 26.88,68.09 26.88,69.61 27.61,70.35 27.61,81.27 27.16,81.73 27.16,94.34 27.79,94.97 27.79,97.38 29.8,99.39 29.8,99.73 30.93,100.87 31.88,100.87 v1(32.28,101.27)
  BOTTOM w0.14: U118.8 26.04,16.93 v1(26.24,17.13)
WKUP_UART0_TX_3V3: length 95.8
  TOP w0.132: U18.E9 v1(33.88,101.27)
  L03_SIG01 w0.102: v1(24.99,17.2) 25.54,16.65 26.43,16.65 26.9,17.12 26.9,18.07 26.03,18.94 26.03,20.6 26.28,20.84 26.28,28.7 25.17,29.8 25.17,39.66 25.76,40.26 25.76,45.76 27.23,47.23 27.23,49.92 28.15,50.84 28.15,60.49 28.48,60.82 28.48,74.07 29.15,74.75 29.15,81.99 27.61,83.53 27.61,94.15 28.25,94.78 28.25,97.09 30.42,99.27 31.65,99.27 31.88,99.5 31.88,99.83 32.11,100.07 32.45,100.07 32.68,100.3 32.68,100.64 32.91,100.87 33.48,100.87 v1(33.88,101.27)
  BOTTOM w0.14: U118.6 25.24,16.95 24.99,17.19 v1(24.99,17.2) 24.99,17.59 R535.2
WL_LT_EN: length 9.6
  TOP w0.14: U1.8 44.78,151.53 44.94,151.69 R6.1 R7.2 46.15,150.78 46.65,150.28 46.65,147.18 47.36,146.47 48.2,146.47 48.51,146.78 U2.9
WLAN_ALERT_1V8: length 34.5
  TOP w0.14: U1.5 v1(42.9,148.2) ; v1(11.78,148.74) 11.88,148.84 R8.2
  L05_SIG02 w0.102: v1(11.78,148.74) 26.76,148.74 28.89,150.87 37.83,150.87 38.9,149.8 40.96,149.8 42.56,148.2 v1(42.9,148.2)
WLAN_ALERTN: length 143.7
  TOP w0.14: v1(44.19,153) R2.1 43.28,153.54 42.9,153.16 U1.10
  L03_SIG01 w0.102: v1(60.96,50.59) 63.41,50.59 66.06,53.24 67.99,53.24 v1(72.27,57.52)
  L05_SIG02 w0.102: v1(72.27,57.52) 71.53,58.25 71.53,63.77 70.88,64.42 70.88,101.32 72.63,103.07 72.63,109.95 73.61,110.93 73.61,140.37 70.81,143.17 66.02,143.17 62.18,147 59.67,147 58.98,147.69 48.64,147.69 46.84,149.49 46.84,150.34 v1(44.19,153)
  BOTTOM w0.14: v1(60.96,50.59) 56.2,45.84 U92.16
WLAN_EN: length 53.1
  TOP w0.132: U18.F22 v1(34.68,112.46)
  TOP w0.14: U1.11 v1(42.4,153.37) ; v1(45.19,148.15) R12.2 R11.1
  L05_SIG02 w0.102: v1(45.19,148.15) 43.74,149.59 43.74,152.69 43.06,153.37 v1(42.4,153.37)
  BOTTOM w0.14: v1(45.19,148.15) 44.71,147.66 43.15,147.66 41.7,146.22 40.09,146.22 39.68,145.81 39.68,142.38 37.59,140.3 37.59,137.12 33.38,132.9 33.38,127.19 33.63,126.94 33.63,124.07 33.38,123.81 33.38,117.18 35.12,115.44 35.12,113.89 34.68,113.46 v1(34.68,112.46)
WLAN_EN_1V8: length 1.5
  TOP w0.14: U1.4 R10.2
WLAN_IRQ: length 61.1
  TOP w0.132: U18.E21 v1(33.88,111.66)
  TOP w0.14: J2.21 4.25,139.54 v1(4.75,140.04)
  L05_SIG02 w0.102: v1(16.86,124.52) 16.46,124.52 15.53,125.46 14.62,125.46 14.35,125.73 12.29,125.73 10.52,127.51 10.52,135.07 9.5,136.08 9.5,139.71 8.56,140.65 5.36,140.65 v1(4.75,140.04)
  L10_SIG03 w0.102: v1(16.86,124.52) 17.11,124.27 17.11,122.37 15.78,121.03 15.78,113.54 19.04,110.28 24.57,110.28 24.88,110.58 25.63,110.58 25.99,110.94 28.37,110.94 29.5,112.06 33.48,112.06 v1(33.88,111.66)
  BOTTOM w0.14: R262.1 v1(4.75,140.04)
WLAN_SDIO_RST: length 55.8
  TOP w0.14: U1.2 41.4,148.48 41.26,148.34 R9.1 41.26,147.53 41.05,147.32 v1(40.09,147.32) ; J2.23 v1(3.84,140.04)
  L05_SIG02 w0.102: v1(40.09,147.32) 39.57,147.32 36.82,150.07 29.48,150.07 23.68,144.26 15.17,144.26 13.59,142.68 11.18,142.68 10.19,143.67 10.19,146.67 8.56,148.31 5.6,148.31 3.84,146.54 v1(3.84,140.04)
XDS110_DIR: length 3.1
  BOTTOM w0.14: 65.56,21.71 65.41,21.85 65.41,22.05 R517.2 ; 65.56,21.71 65.71,21.86 66.2,21.86 66.34,21.72 U111.5 ; 65.56,21.71 65.56,21.11 65.73,20.93 U111.4
XDS110_EMU0: length 21.2
  TOP w0.14: U47.42 70.78,13.43 71.14,13.07 R234.2 71.57,12.55 71.95,12.16 v1(72.49,12.16)
  L05_SIG02 w0.102: v1(64.04,17.51) 64.04,13.25 67.43,9.85 70.18,9.85 v1(72.49,12.16)
  BOTTOM w0.14: v1(64.04,17.51) 63.51,17.51 62.81,18.22 U112.7
XDS110_EMU1: length 15.3
  TOP w0.14: U47.43 R233.2 71.57,14.34 71.42,14.48 v1(71.1,14.48)
  BOTTOM w0.14: v1(71.1,14.48) 68.72,14.48 68.26,14.94 67.32,14.94 66.72,14.33 65.87,14.33 65.52,14.69 65.52,17.56 64.96,18.11 63.59,18.11 63.16,18.55 U112.6
XDS110_TCK: length 11.7
  TOP w0.14: U47.35 68.61,10.63 v1(68.28,10.3)
  L05_SIG02 w0.102: v1(67.34,18.15) 67.67,17.82 67.67,15.76 67.26,15.36 67.26,10.67 67.63,10.3 v1(68.28,10.3)
  BOTTOM w0.14: U111.14 67.14,18.34 v1(67.34,18.15)
XDS110_TDI: length 9.9
  TOP w0.14: U47.38 68.86,11.83 68.81,11.77 68.11,11.77 67.12,12.76 67.12,15.38 66.47,16.03 v1(66.47,18.13)
  BOTTOM w0.14: v1(66.47,18.13) 66.74,18.39 U111.15
XDS110_TDO: length 18.4
  TOP w0.14: U47.37 67.93,11.43 67.81,11.55 65.41,11.55 64.26,12.69 64.26,14.24 63.93,14.57 63.93,16.92 62.88,17.97 62.88,19.09 61.97,20 61.78,20 v1(60.52,21.27)
  BOTTOM w0.14: v1(60.52,21.27) 59.92,20.67 U109.7
XDS110_TMS: length 10.9
  TOP w0.14: U47.36 v1(67.66,11.03)
  L05_SIG02 w0.102: v1(67.66,11.03) 67.66,13.6 68.07,14.01 v1(68.07,18.55)
  BOTTOM w0.14: U111.13 67.54,18.7 67.69,18.55 v1(68.07,18.55)
XDS110_TRST#: length 9.2
  TOP w0.132: v1(68.69,19.01) 68.69,18.48 67.98,17.77 67.98,13.65 69,12.63 U47.40
  BOTTOM w0.14: U111.12 67.97,19.73 v1(68.69,19.01)
XDS_GPIO1: length 1.8
  TOP w0.14: v1(64.49,28.63) 64.6,28.52 U44.2
  BOTTOM w0.14: R484.2 v1(64.49,28.63)
XDS_GPIO2: length 2.4
  BOTTOM w0.14: U102.7 59.35,27.99 R481.2
XDS_GPIO3: length 1.8
  TOP w0.14: U44.4 v1(65.4,28.63)
  BOTTOM w0.14: R483.2 v1(65.4,28.63)
XDS_GPIO4: length 1.9
  TOP w0.14: v1(66.39,28.63) 66.2,28.44 U44.6
  BOTTOM w0.14: v1(66.39,28.63) 66.52,28.51 R482.2
XDS_I2C1_EN: length 3.7
  BOTTOM w0.14: R470.1 R471.2 60.97,34.76 61.47,35.27 U97.5
XDS_PORZN: length 2.1
  TOP w0.14: v1(66.52,34.39) 66.6,34.3 U44.8
  BOTTOM w0.14: v1(66.52,34.39) 66.22,34.39 66.06,34.23 R472.2
XDS_POWERDOWN: length 2.5
  TOP w0.14: U44.12 65,35.05 64.8,35.26 R194.2
XDS_RSTN: length 5.6
  TOP w0.14: v1(66.64,22.55) 66.64,22.58 66.37,22.85 U47.70 66.37,25.35 TP78.1
  BOTTOM w0.14: v1(66.64,22.55) 66.64,22.97 R506.1 65.51,23.61 65.13,23.23 R511.1
XDS_SHIELD:
  vias: v1(77.57,12.08) v1(78.59,11.52) v1(78.59,10.61) v1(79.02,22.16) v1(80.8,22.16) v1(81.71,22.16) v1(82.07,18.25) v1(82.07,16.73) v1(82.07,15.2) v1(83.59,18.25) v1(83.59,16.73) v1(83.59,15.2)
XDS_USB_DM: length 29.7
  TOP w0.102: J18.2 78.63,16.1 78.41,16.32 78.01,16.32 v1(77.73,16.05) ; U47.93 57.12,23.68 57.12,22.87 57.07,22.82 57.07,22.45 v1(57.35,22.18)
  L05_SIG02 w0.102: v1(77.73,16.05) 77.73,16.32 77.63,16.42 76.09,16.42 75.72,16.8 74.94,16.8 71.55,20.2 71.22,20.2 67.9,23.51 57.74,23.51 56.99,22.76 56.99,22.53 v1(57.35,22.18)
  BOTTOM w0.102: v1(77.73,16.05) 77.46,16.32 77.25,16.32 77.1,16.18 U115.5
XDS_USB_DP: length 29.7
  TOP w0.102: v1(56.59,22.18) 56.86,22.45 56.86,22.82 56.81,22.87 56.81,23.68 U47.94 ; J18.3 78.63,16.75 78.41,16.53 78.01,16.53 v1(77.73,16.81)
  L05_SIG02 w0.102: v1(56.59,22.18) 56.79,22.38 56.79,22.85 57.65,23.71 67.99,23.71 71.3,20.4 71.63,20.4 75.03,17 75.8,17 76.18,16.63 77.55,16.63 v1(77.73,16.81)
  BOTTOM w0.102: v1(77.73,16.81) 77.46,16.53 77.25,16.53 77.1,16.68 U115.4
XDS_USB_ID: length 38.6
  TOP w0.14: R204.2 v1(56.68,27.17) ; v1(75.66,16.18) 76.24,16.18 77.47,17.4 J18.4
  L03_SIG01 w0.102: v1(75.66,16.18) 73.39,13.91 57.76,13.91 56.15,15.52 56.15,22.76 56.68,23.29 v1(56.68,27.17)
  BOTTOM w0.14: U115.2 v1(75.66,16.18)
XDS_USB_VBUS: length 4.6
  TOP w0.254: R237.1 49.21,7.26 49,7.46 v1(49,7.93) ; TP89.1 74.73,14.36 C155.1
  BOTTOM w0.254: R507.1 78.98,24.46 v1(78.72,24.73) ; R496.1 57.06,25.74 v1(57.44,26.12) ; U115.6 76.77,15.26 v1(76.6,15.09)
  vias: v1(74.16,21.63) v1(74.16,20.71) v1(74.94,20.71) v1(75.68,15.09) v1(77.51,15.09)
XDS_VREF: length 18.4
  TOP w0.203: U47.9 59.17,7.23 59.51,6.88 C165.2
  TOP w0.254: U49.3 C161.1 72.69,7.13 72.44,6.88 R239.2 v1(70.58,7.39) ; C165.2 v1(59.87,6.31)
  L03_SIG01 w0.305: v1(70.58,7.39) 70.16,7.81 61.04,7.81 60.3,7.07 60.3,6.74 v1(59.87,6.31)
XDS_WARMRESETN: length 1.5
  TOP w0.14: R198.2 65.91,34.37 65.8,34.27 U44.10
N15951749: length 7.3
  BOTTOM w0.254: C177.1 R264.2 R272.2 ; C177.1 U56.4 ; C177.1 23.63,138.25 24.28,137.6 24.28,135.79 24.06,135.56 U56.1
N15952254: length 1.5
  BOTTOM w0.14: U56.3 20.65,136.96 20.46,136.77 R280.1
N16839912: length 2.4
  BOTTOM w0.14: U82.D3 3.9,73.76 C385.1 4.01,74.42 4.15,74.56 R375.1
N16839940: length 2.5
  BOTTOM w0.14: U83.D3 41.15,68.38 C392.1 41.15,70.14 41.28,70.27 R378.1
N16839975: length 2.5
  BOTTOM w0.14: U85.D3 31.86,68.38 C394.1 31.86,70.17 32.01,70.31 R382.1
N16856152: length 5.2
  TOP w0.14: U48.3 15.84,17.21 15.56,16.93 C149.1 14,16.93 12.63,15.56 Y5.2
N16856224: length 5.2
  TOP w0.14: Y5.1 12.64,19.36 14.01,18 C148.1 15.56,18 15.84,17.71 U48.2
N16857368: length 1.6
  BOTTOM w0.14: C504.2 13.06,10.09 U121.2
N16878333: length 1.2
  BOTTOM w0.14: U119.5 19.91,14.07 19.47,14.51 R560.2
N16878339: length 2.4
  BOTTOM w0.14: R561.1 18.59,14.86 19.08,14.37 19.08,13.41 19.23,13.26 U119.4
N16878497: length 1.9
  TOP w0.14: v1(57.48,79.26) 57.23,79.01 U28.H5
  BOTTOM w0.14: TP100.1 57.42,79.26 v1(57.48,79.26) R368.1
N16880083: length 2.6
  TOP w0.14: U24.1 5.17,91.47 v1(4.86,91.16) 4.86,90.74 5.06,90.53 R106.2
  BOTTOM w0.14: R353.1 4.49,90.79 v1(4.86,91.16)
N16893179: length 1.2
  BOTTOM w0.14: R520.2 31.66,21.47 31.22,21.03 U110.5
N16893185: length 2.4
  BOTTOM w0.14: U110.4 30.41,21.72 30.57,21.88 31.2,21.88 31.69,22.36 R516.1
N16894003: length 1.4
  BOTTOM w0.14: R540.2 24.14,17.17 24.56,16.75 24.74,16.75 24.84,16.64 U118.5
N16894009: length 2.5
  BOTTOM w0.14: R541.1 23.25,17.17 23.99,16.43 23.99,15.73 24.15,15.57 U118.4
N16906426: length 4.8
  TOP w0.14: R71.1 25.63,105.47 25.01,106.09 C33.2 24.05,106.09 23.83,106.3 22.55,106.3 22.24,106 22.24,105.8 Y1.1
N16906432: length 2.6
  TOP w0.14: R74.1 C36.2 23.8,104.04 23.65,104.19 Y1.3
N16927060: length 1.9
  TOP w0.14: R57.2 14.94,112.01 14.94,112.48 15.22,112.77 U13.72
N16927228: length 1.1
  TOP w0.14: U13.69 R54.1
N16927289: length 1.3
  TOP w0.14: R48.2 26.16,121.76 25.68,121.27 U13.36
N16929458: length 2.6
  TOP w0.14: TP62.1 v1(79.69,47.29)
  BOTTOM w0.14: v1(79.69,47.29) 79.19,47.79 U88.7
N16929460: length 1.5
  TOP w0.14: TP61.1 v1(78.77,47.29)
  BOTTOM w0.14: U88.8 v1(78.77,47.29)
N16929474: length 1.8
  BOTTOM w0.14: U88.41 73.62,51.58 73.62,52.68 R404.2
N16929699: length 1.4
  TOP w0.14: C115.1 v1(78.77,49.29)
  BOTTOM w0.14: U88.4 v1(78.77,49.29)
N16929703: length 1.4
  TOP w0.14: C119.1 v1(78.77,48.29)
  BOTTOM w0.14: U88.6 v1(78.77,48.29)
N16929744: length 1.6
  TOP w0.14: TP67.1 v1(73.91,43.69)
  BOTTOM w0.14: U88.19 74.16,43.94 v1(73.91,43.69)
N16929747: length 1.6
  TOP w0.14: TP66.1 v1(72.91,43.69)
  BOTTOM w0.14: v1(72.91,43.69) 72.66,43.94 U88.22
N16929749: length 1.9
  BOTTOM w0.14: TP102.1 69.53,50.29 U88.35
N16929751: length 3.2
  BOTTOM w0.14: U88.34 70.12,49.79 69.77,49.44 68.56,49.44 TP103.1
N16931396: length 1.5
  BOTTOM w0.14: R270.2 6.44,138.1 6.11,137.76 U53.B2
N16931420: length 1.2
  BOTTOM w0.14: R281.1 5.12,136.78 U53.C1
N16943223: length 1.7
  TOP w0.14: R33.1 50.7,135.73 U7.2
N16947096: length 1.4
  TOP w0.14: R23.1 U6.1
N16960546: length 1.5
  TOP w0.14: U12.B2 v1(50.35,120.4)
  BOTTOM w0.14: R313.2 v1(50.35,120.4)
N16990175: length 2.7
  BOTTOM w0.14: J23.27 60.75,14.3 61.77,15.32 R555.2
N16990176: length 2.4
  BOTTOM w0.14: J23.30 59.25,14.64 59.51,14.9 R556.2
N16990179: length 4.7
  BOTTOM w0.14: R533.2 58.21,17.84 58.57,17.48 58.57,15.09 58.75,14.92 J23.31
N16990180: length 2.7
  BOTTOM w0.14: J23.32 58.25,14.61 R557.2
N16990246: length 4.4
  BOTTOM w0.14: J23.26 61.25,14.24 61.64,14.64 63.47,14.64 63.95,15.12 R554.2
N16990247: length 5.1
  BOTTOM w0.14: J23.28 60.25,14.5 61.08,15.33 61.08,17.16 60.4,17.84 R532.2
N16990252: length 5.3
  BOTTOM w0.14: J23.33 57.75,14.32 57.44,14.63 56.86,14.63 56.63,14.86 56.63,17.24 R536.2
N16994873: length 1.2
  BOTTOM w0.14: U107.4 47.11,24.21 47.18,24.28 R499.2
N16994875: length 1.1
  BOTTOM w0.102: R562.2 U117.4
N16995245: length 0.9
  BOTTOM w0.14: R519.2 C474.1
N16997746: length 5.6
  TOP w0.14: U47.59 70.89,20.23 71.07,20.05 71.07,19.35 71.42,19.01 73.8,19.01 74.33,19.53 R232.1
N17030208: length 1.6
  BOTTOM w0.14: U111.7 67.14,22.15 67.43,22.43 R515.2
N17031262: length 1.7
  TOP w0.254: LD6.2 R203.2
N17078351: length 1.5
  TOP w0.14: SW2.13 R209.1
N17078353: length 1.5
  TOP w0.14: SW2.14 R210.1
N17078355: length 1.5
  TOP w0.132: SW2.15 R211.1
N17078357: length 1.5
  TOP w0.102: 41.01,27.42 R212.1
  TOP w0.14: SW2.16 41.01,27.42
N17078758: length 1.5
  TOP w0.14: SW3.11 R215.1
N17078760: length 1.5
  TOP w0.14: SW3.12 R216.1
N17078762: length 1.5
  TOP w0.14: SW3.13 R217.1
N17078764: length 1.5
  TOP w0.14: SW3.14 R218.1
N17078766: length 1.5
  TOP w0.14: SW3.9 R213.1
N17078768: length 1.5
  TOP w0.14: SW3.10 R214.1
N17078770: length 1.5
  TOP w0.14: SW3.15 R219.1
N17078778: length 1.5
  TOP w0.14: SW3.16 R220.1
N17078974: length 2
  BOTTOM w0.14: R495.2 81.1,25.22 81.31,25.01 J16.2
N17084256: length 1.5
  TOP w0.132: SW2.9 R205.1
N17084257: length 1.5
  TOP w0.14: SW2.10 R206.1
N17084258: length 1.5
  TOP w0.14: SW2.11 R207.1
N17084259: length 1.5
  TOP w0.14: SW2.12 R208.1
N17110597: length 1.5
  TOP w0.14: v1(64.16,91.39) TP26.1
  BOTTOM w0.14: v1(64.16,91.39) U78.13
N17137240: length 1.6
  BOTTOM w0.14: J6.11 R330.2
N17153379: length 15.6
  TOP w0.14: v1(14.48,93.48) 14.64,93.64 R101.3 ; v1(2.4,95.54) 1.86,95.54 1.72,95.4 R102.2
  L03_SIG01 w0.102: v1(2.4,95.54) 3.13,94.81 4.07,94.81 4.68,94.2 8.37,94.2 9.2,93.36 14.36,93.36 v1(14.48,93.48)
N17153381: length 15
  TOP w0.14: v1(14.82,95.24) 14.99,95.24 15.09,95.34 R101.2 ; R103.2 2.87,95.43 3,95.56 v1(3.29,95.56)
  L03_SIG01 w0.102: v1(14.82,95.24) 14.72,95.14 14.69,95.14 13.2,93.64 9.5,93.64 8.66,94.48 4.83,94.48 4.19,95.11 3.66,95.11 3.29,95.48 v1(3.29,95.56)
N17153383:
  vias: v1(25.33,86.7) v1(25.33,86.06)
N17153415: length 24.2
  L05_SIG02 w0.102: v1(36.51,72.46) 36.14,72.46 36.04,72.56 36.04,73.11 34.37,74.78 30.18,74.78 27.38,77.58 27.38,78.86 v1(26.88,79.36)
  BOTTOM w0.14: R356.1 26.3,87.7 26.68,87.32 26.68,82.07 27.23,81.52 27.23,79.72 v1(26.88,79.36) ; R380.2 v1(36.51,72.46)
N17153417: length 25.6
  L05_SIG02 w0.102: v1(26.88,78.27) 26.88,77.72 30.11,74.49 34.24,74.49 35.76,72.97 35.76,72.65 35.58,72.46 v1(35.24,72.46)
  BOTTOM w0.14: R381.2 v1(35.24,72.46) ; R356.4 25.88,89.25 27.01,88.12 27.01,82.15 27.54,81.62 27.54,78.93 v1(26.88,78.27)
N17153507: length 11.3
  TOP w0.14: R66.2 10.92,105.66 11.18,105.4 v1(11.18,105.17) ; v1(10.67,97.08) 10.67,96.71 10.91,96.47 R94.1
  BOTTOM w0.14: v1(11.18,105.17) 9.71,103.7 9.71,101.51 10.01,101.21 10.01,97.73 v1(10.67,97.08)
