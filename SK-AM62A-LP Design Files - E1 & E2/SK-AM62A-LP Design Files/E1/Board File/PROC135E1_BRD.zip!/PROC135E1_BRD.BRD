# Allegro board PROC135E1_BRD.BRD (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R306  10K  [RES0201_0-5]  48.93 121.38 270 bottom
R307  10K  [RES0201_0-5]  59.22 120.68 180 bottom
R308  4.3K_1%  [RES0402_0-5]  15.53 120.53 270 bottom
R309  22E_1%  [RES0201_0-5]  51.31 120.49 270 bottom
R310  2.2K  [RES0402_0-5]  20.26 120.21 180 bottom
R311  100K  [RES0201_0-5]  48.42 119.93 90 bottom
R312  0E  [RES0201_0-5]  51.31 119.93 270 bottom
R313  0E  [RES0402_0-5]  49.86 119.65 0 bottom
R314  10K  [RES0201_0-5]  56.68 114.8 270 bottom
R315  49.9K_1%  [RES0201_0-5]  34.16 114.69 0 bottom
R316  0E  [RES0201_0-5]  35.61 114.28 90 bottom
R317  0E  [RES0201_0-5]  1.29 113.59 90 bottom
R318  0E  [RES0201_0-5]  47.48 113.35 90 bottom
R319  0E  [RES0201_0-5]  38.08 113.35 270 bottom
R320  0E  [RES0201_0-5]  36.28 113.35 270 bottom
R321  0E  [RES0201_0-5]  33.88 113.35 270 bottom
R322  0E  [RES0201_0-5]  49.12 108.46 0 bottom
R323  0E  [RES0402_0-5]  18.66 107.87 180 bottom
R324  10K  [RES0201_0-5]  18.53 106.53 90 bottom
R325  0E  [RES0201_0-5]  67.18 105.36 180 bottom
R326  22E_1%  [RES0201_0-5]  28.65 105.28 0 bottom
R327  0E  [RES0201_0-5]  80.8 105.26 270 bottom
R328  499E_0.1%  [RES0402_0-5]  49.79 104.15 180 bottom
R329  0E  [RES0201_0-5]  70.83 104.08 90 bottom
R330  220E  [RES0402_0-5]  80.85 103.46 270 bottom
R331  499E_0.1%  [RES0402_0-5]  49.79 103.01 0 bottom
R332  17.8K_1%  [RES0402_0-5]  22.46 102.55 180 bottom
R333  2.49K_1%  [RES0402_0-5]  59.53 102.31 270 bottom
R334  2.49K_1%  [RES0402_0-5]  58.26 102.31 270 bottom
R335  2.2K  [RES0201_0-5]  60.67 102.01 90 bottom
R336  2.49K_1%  [RES0402_0-5]  63.4 101.38 270 bottom
R337  2.49K_1%  [RES0402_0-5]  62.13 101.38 270 bottom
R338  10K_1%  [RES0201_0-5]  45.48 100.71 0 bottom
R339  5.76K_1%  [RES0402_0-5]  57.49 100.26 270 bottom
R340  2.49K_1%  [RES0402_0-5]  56.05 100.26 270 bottom
R341  22E_1%  [RES0201_0-5]  59.4 100.23 270 bottom
R342  22E_1%  [RES0201_0-5]  58.51 100.23 270 bottom
R343  22E_1%  [RES0201_0-5]  49.99 99.94 180 bottom
R344  499E_0.1%  [RES0402_0-5]  48.24 99.35 90 bottom
R345  10K_1%  [RES0201_0-5]  45.48 99.11 0 bottom
R346  2.49K_1%  [RES0402_0-5]  55.05 98.16 180 bottom
R347  2.49K_1%  [RES0402_0-5]  55.05 96.66 180 bottom
R348  0E  [RES0402_0-5]  55.05 95.51 0 bottom
R349  240E_1%  [RES0402_0-5]  36.41 94.34 270 bottom
R350  2.2K  [RES0402_0-5]  42.89 92.6 180 bottom
R351  11K_1%  [RES0402_0-5]  65.93 91.24 0 bottom
R352  2.2K  [RES0402_0-5]  42.89 91.53 0 bottom
R353  10K  [RES0201_0-5]  4.19 90.51 270 bottom
R354  10K  [RES0201_0-5]  62.28 89.43 270 bottom
R355  1.5K  [RES0201_0-5]  61.52 89.43 90 bottom
R356  0.01E_1%  [RES_KRL3216T4_1206-4_0-7]  23.76 88.47 90 bottom
R357  100K_1%  [RES0402_0-5]  61.29 87.26 90 bottom
R358  316K_1%  [RES0402_0-5]  60.02 87.26 270 bottom
R359  0E  [RES0603_0-75]  23.19 85.76 0 bottom
R360  100K_1%  [RES0402_0-5]  59.79 85.1 180 bottom
R361  0E  [RES0201_0-5]  60.04 83.99 0 bottom
R362  0E  [RES0201_0-5]  11.58 83.04 270 bottom
R363  0E  [RES0201_0-5]  12.79 82.13 270 bottom
R364  0E  [RES0201_0-5]  78.58 81.79 0 bottom
R365  0E  [RES0201_0-5]  81.3 81.57 90 bottom
R366  220E  [RES0402_0-5]  80.16 81.31 270 bottom
R367  220E  [RES0402_0-5]  82.82 81.29 270 bottom
R368  10K_1%  [RES0201_0-5]  58.28 79.26 0 bottom
R369  2.2K  [RES0402_0-5]  41.53 78.75 180 bottom
R370  2.2K  [RES0402_0-5]  37.21 78.75 0 bottom
R371  49.9K_1%  [RES0201_0-5]  58.16 77.97 90 bottom
R372  49.9K_1%  [RES0201_0-5]  55.69 77.51 0 bottom
R373  49.9K_1%  [RES0201_0-5]  57.48 76.68 90 bottom
R374  0E  [RES0201_0-5]  18.37 75.87 0 bottom
R375  10E_1%  [RES0402_0-5]  4.15 75.54 90 bottom
R376  10E_1%  [RES0402_0-5]  2.88 75.54 90 bottom
R377  0E  [RES0201_0-5]  5.26 71.77 90 bottom
R378  10E_1%  [RES0402_0-5]  41.28 71.24 90 bottom
R379  10E_1%  [RES0402_0-5]  40.01 71.24 90 bottom
R380  10E_1%  [RES0402_0-5]  36.51 71.24 90 bottom
R381  10E_1%  [RES0402_0-5]  35.24 71.24 90 bottom
R382  10E_1%  [RES0402_0-5]  32.01 71.24 90 bottom
R383  10E_1%  [RES0402_0-5]  30.74 71.24 90 bottom
R384  1K_1%  [RES0402_0-5]  2.44 69.86 180 bottom
R385  0E  [RES0201_0-5]  37.6 67.54 90 bottom
R386  0E  [RES0201_0-5]  42.39 67.5 90 bottom
R387  0E  [RES0201_0-5]  33.03 66.67 270 bottom
R388  4.7K  [RES0201_0-5]  42.53 66.38 180 bottom
R389  0E  [RES0603_0-75]  79.68 64.82 270 bottom
R390  10K  [RES0201_0-5]  45.07 60.59 0 bottom
R391  4.7K  [RES0201_0-5]  39.99 60.59 180 bottom
R392  1.1K_1%  [RES0201_0-5]  80.39 60 180 bottom
R393  0E  [RES0201_0-5]  66.02 59.54 0 bottom
R394  0E  [RES0201_0-5]  63.48 59.54 0 bottom
R395  0E  [RES0201_0-5]  66.02 58.77 0 bottom
R396  0E  [RES0201_0-5]  63.48 58.77 0 bottom
R397  0.005E_1%  [RES1206_1]  32 56.12 180 bottom
R398  0E  [RES0201_0-5]  44.03 55.74 270 bottom
R399  10K_1%  [RES0201_0-5]  68.65 55.72 90 bottom
R400  100K_1%  [RES0402_0-5]  45.42 55.07 270 bottom
R401  10K  [RES0201_0-5]  44.03 54.3 270 bottom
R402  10K  [RES0201_0-5]  77.1 53.86 270 bottom
R403  10K  [RES0201_0-5]  76.19 53.86 270 bottom
R404  0E  [RES0201_0-5]  73.18 53.4 270 bottom
R405  0E  [RES0201_0-5]  80.43 53.27 270 bottom
R406  0E  [RES0201_0-5]  79.41 53.27 270 bottom
R407  0E  [RES0201_0-5]  71.66 53.26 90 bottom
R408  4.7K  [RES0201_0-5]  22.88 52.99 180 bottom
R409  4.7K  [RES0201_0-5]  21.21 52.12 0 bottom
R410  10K  [RES0201_0-5]  47.17 52 270 bottom
R411  0E  [RES0402_0-5]  67.04 51.58 90 bottom
R412  10K  [RES0201_0-5]  20.98 50.64 270 bottom
R413  1M_1%  [RES0402_0-5]  18.66 50.59 270 bottom
R414  10K  [RES0201_0-5]  24.21 50.54 270 bottom
R415  10K  [RES0201_0-5]  23.29 50.54 270 bottom
R416  0E  [RES0201_0-5]  17.25 50.24 0 bottom
R417  0E  [RES0402_0-5]  30.95 49.24 180 bottom
R418  0E  [RES0402_0-5]  30.47 47.97 180 bottom
R419  10K  [RES0201_0-5]  25.5 47.89 180 bottom
R420  10E  [RES0402_0-5]  37.79 47.42 270 bottom
R421  0E  [RES0201_0-5]  25.5 47.13 180 bottom
R422  0E  [RES0201_0-5]  25.5 46.37 180 bottom
R423  44.2K_1%  [RES0402_0-5]  30.22 45.86 180 bottom
R424  100K_1%  [RES0402_0-5]  13.56 45.8 180 bottom
R425  0E  [RES0201_0-5]  15.61 45.72 90 bottom
R426  0E  [RES0201_0-5]  25.5 45.16 0 bottom
R427  10K  [RES0201_0-5]  59.93 44.97 180 bottom
R428  10K_1%  [RES0201_0-5]  15.24 44.66 0 bottom
R429  100K_1%  [RES0402_0-5]  13.56 44.53 180 bottom
R430  10K  [RES0201_0-5]  61.21 44.41 90 bottom
R431  0E  [RES0201_0-5]  25.5 44.4 0 bottom
R432  10K  [RES0201_0-5]  59.93 44.21 0 bottom
R433  4.7K  [RES0201_0-5]  48.6 44.11 90 bottom
R434  4.7K  [RES0201_0-5]  47.71 44.11 90 bottom
R435  0E  [RES0402_0-5]  68.03 43.72 180 bottom
R436  0E  [RES0201_0-5]  25.5 43.64 0 bottom
R437  2.2K_1%  [RES0201_0-5]  78.35 43.49 180 bottom
R438  10K  [RES0201_0-5]  45.28 42.63 0 bottom
R439  0E  [RES0201_0-5]  24.69 42.52 270 bottom
R440  10K  [RES0201_0-5]  63.73 42.34 180 bottom
R441  2.05K_1%  [RES0402_0-5]  37.09 41.86 0 bottom
R442  10K  [RES0201_0-5]  44.72 41.75 0 bottom
R443  10K  [RES0402_0-5]  35.14 41.04 270 bottom
R444  10K  [RES0402_0-5]  32.07 40.52 270 bottom
R445  100K_1%  [RES0201_0-5]  22.39 39.88 270 bottom
R446  0E  [RES0201_0-5]  18.29 39.71 270 bottom
R447  0E  [RES0402_0-5]  21.14 39.68 90 bottom
R448  0E  [RES0201_0-5]  50.26 39.23 0 bottom
R449  1K_1%  [RES0402_0-5]  19.69 39.05 270 bottom
R450  10K  [RES0201_0-5]  62.11 39.02 90 bottom
R451  10K  [RES0201_0-5]  51.82 38.95 270 bottom
R452  10K  [RES0201_0-5]  56.11 38.8 180 bottom
R453  100K_1%  [RES0402_0-5]  18.29 38.07 270 bottom
R454  10K  [RES0201_0-5]  57.29 38.04 180 bottom
R455  100K  [RES0201_0-5]  41.01 37.12 90 bottom
R456  100K  [RES0201_0-5]  39.74 37.12 90 bottom
R457  100K  [RES0201_0-5]  38.47 37.12 90 bottom
R458  100K  [RES0201_0-5]  37.2 37.12 90 bottom
R459  100K  [RES0201_0-5]  35.93 37.12 90 bottom
R460  100K  [RES0201_0-5]  34.66 37.12 90 bottom
R461  100K  [RES0201_0-5]  33.39 37.12 90 bottom
R462  100K  [RES0201_0-5]  32.12 37.12 90 bottom
R463  10K  [RES0201_0-5]  47.18 37.02 180 bottom
R464  0E  [RES0201_0-5]  60.58 36.45 0 bottom
R465  10K  [RES0201_0-5]  55.23 36.28 90 bottom
R466  0E  [RES0201_0-5]  60.58 35.56 0 bottom
R467  10K_1%  [RES0201_0-5]  15.42 35.52 90 bottom
R468  10K_1%  [RES0201_0-5]  16.56 35.09 180 bottom
R469  0E  [RES0201_0-5]  22.09 33.75 90 bottom
R470  1K_1%  [RES0402_0-5]  62.43 33.64 0 bottom
R471  10K  [RES0201_0-5]  60.69 33.64 0 bottom
R472  0E  [RES0201_0-5]  66.06 33.62 90 bottom
R473  10K  [RES0201_0-5]  67.33 33.53 0 bottom
R474  1K_1%  [RES0402_0-5]  69.06 33.4 0 bottom
R475  10K_1%  [RES0201_0-5]  14.35 32.84 90 bottom
R476  0E  [RES0201_0-5]  69.47 31.6 180 bottom
R477  4.7K  [RES0201_0-5]  61.47 31.6 0 bottom
R478  0E  [RES0201_0-5]  69.47 30.71 180 bottom
R479  4.7K  [RES0201_0-5]  61.47 30.71 0 bottom
R480  10K  [RES0201_0-5]  50.11 28.85 180 bottom
R481  0E  [RES0201_0-5]  58.86 28.76 270 bottom
R482  0E  [RES0201_0-5]  66.8 28.12 180 bottom
R483  0E  [RES0201_0-5]  65.4 27.8 90 bottom
R484  0E  [RES0201_0-5]  64.49 27.8 90 bottom
R485  10K_1%  [RES0201_0-5]  17.65 27.29 0 bottom
R486  10K  [RES0201_0-5]  80.53 27.27 270 bottom
R487  30K  [RES0402_0-5]  77.79 27.26 90 bottom
R488  51K  [RES0402_0-5]  76.52 27.26 270 bottom
R489  10K  [RES0201_0-5]  46.96 27.19 0 bottom
R490  10K  [RES0201_0-5]  42.15 27.15 180 bottom
R491  10K  [RES0201_0-5]  59.97 26.8 0 bottom
R492  10K  [RES0201_0-5]  62.91 26.32 270 bottom
R493  0E  [RES0201_0-5]  63.99 26.04 180 bottom
R494  1K_1%  [RES0402_0-5]  61.21 25.78 0 bottom
R495  1.1K_1%  [RES0201_0-5]  80.53 25.5 270 bottom
R496  100E_1%  [RES0402_0-5]  56.79 25.25 270 bottom
R497  10K  [RES0201_0-5]  71.26 24.63 90 bottom
R498  10K  [RES0201_0-5]  70.5 24.63 270 bottom
R499  33E  [RES0201_0-5]  47.58 24.56 270 bottom
R500  0E  [RES0201_0-5]  24.98 24.04 270 bottom
R501  10K  [RES0201_0-5]  24.09 24.04 270 bottom
R502  4.7K  [RES0201_0-5]  62.23 24.02 90 bottom
R503  4.7K  [RES0201_0-5]  61.35 24.02 90 bottom
R504  10K  [RES0201_0-5]  44.46 24.01 90 bottom
R505  10K  [RES0201_0-5]  39.34 23.91 270 bottom
R506  10K  [RES0201_0-5]  66 23.89 90 bottom
R507  0E  [RES0201_0-5]  78.98 23.86 270 bottom
R508  10K  [RES0201_0-5]  14.37 23.81 90 bottom
R509  10K  [RES0201_0-5]  11.96 23.81 90 bottom
R510  10K  [RES0201_0-5]  11.2 23.81 90 bottom
R511  10K  [RES0201_0-5]  64.83 23.23 180 bottom
R512  4.7K  [RES0201_0-5]  37.83 23.53 180 bottom
R513  2.2K  [RES0201_0-5]  13.18 23.53 0 bottom
R514  1K_1%  [RES0402_0-5]  72.73 23.44 0 bottom
R515  22E_1%  [RES0201_0-5]  67.71 23.05 180 bottom
R516  10K  [RES0201_0-5]  32.3 22.36 0 bottom
R517  10K  [RES0201_0-5]  64.89 22.29 0 bottom
R518  1K_1%  [RES0402_0-5]  72.73 22.17 0 bottom
R519  100E_1%  [RES0402_0-5]  45.09 22.05 270 bottom
R520  10K  [RES0201_0-5]  32.3 21.47 180 bottom
R521  10K  [RES0201_0-5]  51.07 20.96 270 bottom
R522  1K_1%  [RES0402_0-5]  72.73 20.9 0 bottom
R523  4.7K  [RES0201_0-5]  33.48 20.71 90 bottom
R524  10K  [RES0201_0-5]  45.81 19.76 0 bottom
R525  1K_1%  [RES0402_0-5]  72.73 19.63 0 bottom
R526  4.7K  [RES0201_0-5]  51.38 19.51 0 bottom
R527  10K  [RES0201_0-5]  57.9 19.2 0 bottom
R528  10K  [RES0201_0-5]  45.81 18.84 180 bottom
R529  22E_1%  [RES0201_0-5]  51.35 18.68 180 bottom
R530  10K  [RES0201_0-5]  61.41 18.35 270 bottom
R531  10K  [RES0201_0-5]  59.23 18.35 270 bottom
R532  0E  [RES0201_0-5]  60.4 18.14 270 bottom
R533  0E  [RES0201_0-5]  58.21 18.14 270 bottom
R534  10K  [RES0201_0-5]  39.16 18.09 180 bottom
R535  4.7K  [RES0201_0-5]  24.85 18.02 270 bottom
R536  0E  [RES0201_0-5]  57.07 17.97 270 bottom
R537  10K  [RES0201_0-5]  45.92 17.92 180 bottom
R538  10K  [RES0201_0-5]  42.74 17.55 90 bottom
R539  10K  [RES0201_0-5]  35.88 17.55 90 bottom
R540  10K  [RES0201_0-5]  24.14 17.46 270 bottom
R541  10K  [RES0201_0-5]  23.25 17.46 90 bottom
R542  10K  [RES0201_0-5]  47.66 17.15 180 bottom
R543  4.7K  [RES0201_0-5]  67.78 16.82 0 bottom
R544  10K  [RES0201_0-5]  31.35 16.65 270 bottom
R545  0E  [RES0201_0-5]  55.83 16.14 270 bottom
R546  10K  [RES0201_0-5]  64.97 16.1 270 bottom
R547  10K  [RES0201_0-5]  62.78 16.1 270 bottom
R548  10K  [RES0201_0-5]  60.52 16.1 270 bottom
R549  0E  [RES0201_0-5]  54.56 16.02 270 bottom
R550  0E  [RES0201_0-5]  53.29 16.02 270 bottom
R551  0E  [RES0201_0-5]  51.46 16.02 270 bottom
R552  4.7K  [RES0201_0-5]  34.96 15.99 180 bottom
R553  12K_1%  [RES0402_0-5]  16.86 15.94 0 bottom
R554  0E  [RES0201_0-5]  63.95 15.89 270 bottom
R555  0E  [RES0201_0-5]  61.77 15.89 270 bottom
R556  0E  [RES0201_0-5]  59.51 15.89 270 bottom
R557  0E  [RES0201_0-5]  57.25 15.89 270 bottom
R558  4.7K  [RES0201_0-5]  20.66 15.46 180 bottom
R559  4.7K  [RES0201_0-5]  66 15.29 90 bottom
R560  10K  [RES0201_0-5]  19.47 15.15 270 bottom
R561  10K  [RES0201_0-5]  18.59 15.15 90 bottom
R562  33E  [RES0201_0-5]  39.15 14.39 0 bottom
R563  100K_1%  [RES0402_0-5]  44.75 13.98 90 bottom
R564  10K  [RES0201_0-5]  35.24 11.49 0 bottom
R565  10K  [RES0201_0-5]  31.14 10.28 90 bottom
R566  10K  [RES0201_0-5]  35.24 10.22 0 bottom
R567  0E  [RES0201_0-5]  42.7 11.13 270 bottom
R568  10K  [RES0201_0-5]  32.04 9.43 270 bottom
R569  0E  [RES0402_0-5]  44.82 8.19 90 bottom
R570  4.7K  [RES0201_0-5]  31.81 7.83 90 bottom
R571  10K  [RES0201_0-5]  61.53 121.56 90 top
R572  4.7K  [RES0201_0-5]  28.68 60.59 180 bottom
R573  0E  [RES0201_0-5]  27.29 60.59 180 bottom
R574  10K  [RES0201_0-5]  20.7 73.7 90 bottom
R575  0E  [RES0201_0-5]  20.14 74.84 180 bottom
RA1  0E  [RESA_EXB_0201-4_0-5]  35.66 118.15 180 top
RA2  0E  [RESA_EXB_0201-4_0-5]  38.08 118.15 180 top
RA3  1K  [RESA_EXB_0201-4_0-5]  20.99 110.14 180 bottom
RA4  1K  [RESA_EXB_0201-4_0-5]  18.74 110.14 180 bottom
RA5  1K  [RESA_EXB_0201-4_0-5]  40.3 39.05 90 bottom
RA6  1K  [RESA_EXB_0201-4_0-5]  32.38 32.72 180 bottom
SW1  7914G-1-000E  [SW4_100X216_200X200_SMD_4-2]  4.62 55.43 270 top
SW2  416131160808  [SW16_416131160808_460X230_SMD_2-7]  36.56 31.46 180 top
SW3  416131160808  [SW16_416131160808_460X230_SMD_2-7]  50.03 31.46 180 top
SW4  7914G-1-000E  [SW4_100X216_200X200_SMD_4-2]  35.52 20.58 0 top
SW5  7914G-1-000E  [SW4_100X216_200X200_SMD_4-2]  42.38 20.58 0 top
TP1  -  [TP20_SMD]  67.08 151.88 0 top
TP2  -  [TP20_SMD]  49.1 145.91 90 top
TP3  -  [TP20_SMD]  50.37 145.91 90 top
TP4  -  [TP20_SMD]  51.64 145.91 90 top
TP5  -  [TP20_SMD]  49.74 144.76 90 top
TP6  -  [TP20_SMD]  51.01 144.76 90 top
TP7  -  [TP20_SMD]  52.28 144.76 90 top
TP8  -  [TP40_SMD]  58.3 106.44 0 top
TP9  -  [TP20_SMD]  32.13 125.4 180 top
TP10  -  [TP20_SMD]  27.54 124.71 180 top
TP11  -  [TP20_SMD]  18.57 123.8 180 top
TP12  -  [TP20_SMD]  27.51 123.36 180 top
TP13  -  [TP20_SMD]  13.12 123.29 0 top
TP14  -  [TP20_SMD]  25.95 123.32 180 top
TP17  -  [TP20_SMD]  67.44 106.85 180 top
TP18  -  [TP20_SMD]  65.47 101.89 0 top
TP19  -  [TP20_SMD]  14.87 100.9 0 top
TP20  -  [TP20_SMD]  58.07 100.48 0 top
TP21  -  [TP20_SMD]  59.24 100.48 0 top
TP22  -  [TP20_SMD]  62.06 99.57 0 top
TP23  -  [TP20_SMD]  63.24 99.57 0 top
TP24  -  [TP20_SMD]  65.55 98.5 0 top
TP25  -  [TP20_SMD]  14.02 92.13 0 top
TP26  -  [TP20_SMD]  65.1 91.39 0 top
TP27  -  [TP20_SMD]  63.68 90.89 0 top
TP28  -  [TP20_SMD]  58.45 88.74 0 top
TP29  -  [TP20_SMD]  66 87.16 90 top
TP30  -  [TP20_SMD]  24.84 84.68 0 top
TP31  -  [TP30_SMD]  10.65 84.31 0 top
TP32  -  [TP20_SMD]  5.19 84.03 0 top
TP33  -  [TP20_SMD]  25.35 83.58 270 top
TP34  -  [TP20_SMD]  23.15 83.51 0 top
TP35  -  [TP20_SMD]  24.23 83.51 0 top
TP36  -  [TP20_SMD]  22.29 75.43 0 top
TP37  -  [TP20_SMD]  22.47 77.44 0 top
TP38  -  [TP20_SMD]  5.44 73.56 270 top
TP39  -  [TP20_SMD]  25.23 73.31 270 top
TP40  -  [TP20_SMD]  42.33 72.3 0 top
TP41  -  [TP20_SMD]  18.28 67.52 0 top
TP42  -  [TP40_SMD]  12.98 67.44 90 top
TP43  -  [TP40_SMD]  14.89 67.44 90 top
TP44  -  [TP40_SMD]  16.79 67.44 90 top
TP45  -  [TP20_SMD]  43.52 60.03 90 top
TP46  -  [TP20_SMD]  27.38 55.74 90 top
TP47  -  [TP20_SMD]  49.92 56.74 0 top
TP48  -  [TP40_SMD]  43.41 55.21 0 top
TP49  -  [TP20_SMD]  79.41 54.83 0 top
TP50  -  [TP20_SMD]  80.43 54.83 0 top
TP51  -  [TP20_SMD]  72.49 54.25 180 top
TP52  -  [TP20_SMD]  73.11 53.38 180 top
TP53  -  [TP20_SMD]  45.99 52.92 0 top
TP54  -  [TP20_SMD]  79.55 52.67 180 top
TP55  -  [TP20_SMD]  78.11 51.75 180 top
TP56  -  [TP20_SMD]  72.16 51.74 180 top
TP57  -  [TP20_SMD]  73.16 51.74 180 top
TP58  -  [TP20_SMD]  18.6 51.4 0 top
TP59  THRU HOLE  [TP_40X65]  82.9 50.56 0 top
TP60  THRU HOLE  [TP_40X65]  82.9 48.02 0 top
TP61  -  [TP20_SMD]  78.77 46.63 180 top
TP62  -  [TP20_SMD]  79.69 46.63 180 top
TP63  -  [TP20_SMD]  57.76 46.24 0 top
TP64  THRU HOLE  [TP_40X65]  82.9 45.48 0 top
TP65  -  [TP20_SMD]  63.34 44.93 0 top
TP66  -  [TP20_SMD]  72.91 43.03 180 top
TP67  -  [TP20_SMD]  73.91 43.03 180 top
TP68  -  [TP20_SMD]  15.18 40.32 0 top
TP69  -  [TP20_SMD]  56.45 38.65 0 top
TP70  -  [TP20_SMD]  46.66 38.65 90 top
TP71  -  [TP20_SMD]  33.31 10.95 180 bottom
TP72  -  [TP20_SMD]  31.49 6.63 180 bottom
TP73  -  [TP20_SMD]  18.06 34.04 180 top
TP74  -  [TP30_SMD]  59.91 30.53 0 top
TP75  -  [TP20_SMD]  68.14 28.86 90 top
TP76  -  [TP20_SMD]  77.91 27.69 90 top
TP77  -  [TP20_SMD]  74.68 27.55 0 top
TP78  -  [TP20_SMD]  66.61 25.59 0 top
TP79  -  [TP20_SMD]  74.54 24.87 0 top
TP80  -  [TP20_SMD]  38.98 24.76 270 top
TP81  -  [TP20_SMD]  22.96 23.31 0 top
TP82  -  [TP20_SMD]  52.99 23.79 90 top
TP83  -  [TP20_SMD]  52.43 22.8 90 top
TP84  -  [TP20_SMD]  52.76 21.71 90 top
TP85  -  [TP20_SMD]  51.84 21.1 90 top
TP86  -  [TP20_SMD]  50.05 16.51 0 top
TP87  -  [TP20_SMD]  39.02 16.39 270 top
TP88  -  [TP20_SMD]  73.89 15.46 0 top
TP89  -  [TP20_SMD]  74.53 14.57 0 top
TP90  -  [TP20_SMD]  29.75 9.02 90 top
TP91  -  [TP20_SMD]  30.13 6.29 90 top
TP92  -  [TP20_SMD]  9.82 138.29 270 bottom
TP93  -  [TP20_SMD]  59.77 137.91 180 bottom
TP94  -  [TP20_SMD]  59.45 136.81 180 bottom
TP95  -  [TP20_SMD]  9.82 135.79 270 bottom
TP96  -  [TP20_SMD]  59.54 135.75 180 bottom
TP97  -  [TP20_SMD]  3.32 135.72 270 bottom
TP98  -  [TP20_SMD]  3.32 134.87 270 bottom
TP99  -  [TP20_SMD]  25.77 104.09 0 bottom
TP100  -  [TP20_SMD]  56.98 78.82 180 bottom
TP101  -  [TP20_SMD]  22.42 76.44 0 top
TP102  -  [TP20_SMD]  69.19 49.95 180 bottom
TP103  -  [TP20_SMD]  68.05 49.95 0 bottom
TP104  -  [TP20_SMD]  58.8 27.52 180 bottom
TP105  -  [TP20_SMD]  63.33 27.5 180 bottom
TP106  -  [TP20_SMD]  43.45 13.49 90 bottom
TP107  -  [TP30_SMD]  56.56 118.76 180 bottom
TP108  -  [TP30_SMD]  56.48 120.32 180 bottom
TP109  -  [TP30_SMD]  55.73 121.33 180 bottom
TP110  THRU HOLE  [TP_40X65]  80.62 135.29 0 top
TP111  THRU HOLE  [TP_40X65]  74.63 7.4 0 top
TP112  THRU HOLE  [TP_40X65]  10.26 7.4 0 top
TP113  THRU HOLE  [TP_40X65]  1.55 126.56 0 top
TP114  THRU HOLE  [TP_40X65]  38.12 153.58 0 top
TP115  -  [TP40_SMD]  37.01 76.32 180 bottom
TP116  -  [TP40_SMD]  75.44 60.24 180 bottom
TP117  -  [TP40_SMD]  14.38 56.29 0 top
U1  TXS0104ERGYR  [QFN14_19-68_145X145]  42.4 150.78 0 top
U2  TCA6424ARGJR  [QFN32_19-68_200X200]  50.26 149.81 0 top
U3  TCA9406DCUR  [VSSOP8_19-68_85X95]  56.12 149.49 90 top
U4  TXB0108RGYR  [QFN20_19-68_185X145_1]  53.71 141.62 180 top
U5  TCA9543APWR  [TSSOP14_25-59_205X180_1-2]  42.77 141.58 270 top
U6  25.000MHz  [OSC4_ECS-2520MV_100X80_SMD_0-9]  47.63 138.48 270 top
U7  LMK1C1104PWR  [TSSOP8_25-59_125X180_1-2]  54.86 135.4 0 top
U8  TS3DV642RUATQ1  [TQFN42_19-68_140X360_0-8]  69.33 133.82 90 top
U9  12.288MHz  [OSC4_KC2016K_80X60_SMD_0-8]  23.25 124.88 0 top
U10  TXS0102DQER  [X2SON8_TXS0102_40X60_0-4]  30.41 124.84 180 top
U11  SN74LVC1G08DBVRE4  [SOT23-5]  41.75 124.33 0 top
U12  W35N01JWTBAG  [TPBGA24_39-37_240X320_1-2]  48.85 121.9 180 top
U13  SiI9022ACNU  [QFN72_19-68_390X390_0-9]  20.44 117.02 90 top
U16  TMP100NA/3K  [SOT23-6_1-5]  19.15 106.22 270 top
U17  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  6.49 105.16 90 top
U18  AM62A_EVM_SoC  [FBGA484_31-49_710X710_2-7]  39.48 103.67 90 top
U20  TPS22918DBVR  [SOT23-6]  8.03 101.89 180 top
U21  TLV705075YFPT  [DSBGA4_15-74_30X30_0-5]  21.25 96.94 180 top
U22  TPD6E001RSER  [UQFN10_19-68_80X60_0-6]  8.17 96.81 270 top
U24  SN74LVC1G11DRYR  [SON6_SN74LVC2G17_40X60_0-6]  5.67 92.07 90 top
U25  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  2.22 90.62 180 top
U26  MT53E2G32D4DE-046 AAT:A  [WFBGA200_MT53E2G32D4DE_400X570_1-2]  39.48 85.27 90 top
U27  PTPS65931211RWERQ1  [VQFN56_19-68_320X320_0-9_EP6]  16.99 79.79 180 top
U28  MTFC16GAPALBH-IT  [VFBGA153_19-68_460X520_1-1]  58.17 79.26 0 top
U29  TMP100NA/3K  [SOT23-6_1-5]  38.07 74.82 180 top
U30  TPD3S014-Q1  [SOT23-6_1-5]  66.5 71.83 0 top
U31  TMUX154EDGSR  [MSOP10_19-68_120X120_1-1]  3.16 71.57 90 top
U32  SN74LVC1G08DBVRE4  [SOT23-5]  60.69 70.07 180 top
U33  SN74CB3Q3257PWR  [TSSOP16_25-59_205X180]  52.87 63.43 90 top
U34  W25Q80DVSNIG  [SOIC8_1-8]  60.87 61.86 180 top
U35  SN74LVC3G17DCUR  [VSSOP8_19-68_85X95_0-9]  10.1 58.83 90 top
U36  SN74LVC1G11DRYR  [SON6_SN74LVC2G17_40X60_0-6]  19.38 56.25 0 top
U37  TPS22965DSGT  [WSON8_19-68_80X80_0-8]  46.5 54.83 0 top
U38  AT24C512C-MAHM-T  [UDFN8_19-68_120X80_0-6]  19.76 53.24 0 top
U39  CSD17308Q3  [VSON8_CSD173_130X130]  39.82 50.59 180 top
U40  SN74LVC1G04DCKR  [SC70-5]  51.93 49.73 90 top
U41  SN74LVC1G11DRYR  [SON6_SN74LVC2G17_40X60_0-6]  63.7 42.75 0 top
U42  SN74LVC1G11DRYR  [SON6_SN74LVC2G17_40X60_0-6]  64.03 39.27 0 top
U43  TPS630702RNMR  [VQFNHR15_TPS630701_100X120_1]  23.96 32.34 270 top
U44  SN74LVC07ADGVR  [TVSOP14_15-74_180X150_1-2]  65.4 30.3 90 top
U45  SN74LVC1G08DBVRE4  [SOT23-5]  70.88 27.31 0 top
U46  TPD2E001DRLR  [SOT553-5_0-6]  8.57 16.57 90 top
U47  TM4C1294NCPDTT3R  [TQFP128_15-74_550X550_1-2]  62.17 16.03 90 top
U48  FT4232HL  [LQFP64_19-68_390X390_1-6]  22.57 14.46 0 top
U49  LM4040B25IDCKR  [SC70-5_1-1]  72.04 9.72 90 top
U50  TLV7103318DSET  [WSON6_19-68_60X60]  58.54 147.65 90 bottom
U51  TXB0104RUTR  [UQFN12_TXB0104RUT_70X80_0-6]  47.39 141.9 180 bottom
U52  SN74CB3Q3257PWR  [TSSOP16_25-59_205X180]  42.77 141.58 90 bottom
U53  TPS22946YZPR  [DSBGA6_19-68_40X60_0-5]  6.11 137.03 90 bottom
U54  SN74AVC4T245RSVR  [UQFN16_TMUX1574_70X100_0-6]  23.02 38.41 90 top
U55  SN74CB3Q3257PWR  [TSSOP16_25-59_205X180]  54.83 136.76 0 bottom
U56  32.768KHz  [OSC4_ECS-327MVATX-2_100X80_SMD_1]  22.32 136.26 180 bottom
U57  TPS22902YFPR  [DSBGA4_15-74_30X30_0-5]  16.57 134.25 90 bottom
U58  TPD12S016PWR  [TSSOP24_25-59_315X180_1-2]  5.85 114.29 0 bottom
U63  TLV75510PDQNR  [X2SON4_TLV71318P_40X40_0-4]  70.25 105.69 270 bottom
U65  TLV75512PDQNR  [X2SON4_TLV71318P_40X40_0-4]  65.58 104.78 0 bottom
U78  DP83867IRRGZ  [QFN48_19-68_280X280_1]  60.9 94.89 180 bottom
U79  TPD2E001DRLR  [SOT553-5_0-6]  17.66 94.53 180 bottom
U81  TPS62824DMQR  [VSONHR6_TPS62826_60X60_1]  62.13 85.1 0 bottom
U82  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  3.5 72.12 0 bottom
U83  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  40.7 67.73 0 bottom
U84  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  35.95 67.73 0 bottom
U85  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  31.41 67.73 0 bottom
U86  12.288MHz  [OSC4_KC2016K_80X60_SMD_0-8]  70.76 55.4 0 bottom
U87  TCA9801DGK  [VSSOP8_25-59_120X120_1-1]  48.14 48.22 90 bottom
U88  TLV320AIC3106IRGZT  [VQFN48_19-68_285X285]  74.41 48.04 180 bottom
U89  LM5141QRGETQ1  [VQFN24_LM5141_160X160_1]  34.28 45.61 0 bottom
U90  TPS65988DHRSHR  [VQFN56_TPS65987D_280X280_1]  20.38 45.16 0 bottom
U91  TVS2200DRVR  [SON6_25-59_85X85_0-8]  9.36 44.83 180 bottom
U92  TCA6424ARGJR  [QFN32_19-68_200X200]  54.45 42.86 0 bottom
U93  SN74LVC1G08DBVRE4  [SOT23-5]  61.16 41.63 270 bottom
U94  SN74LVC1G08DBVRE4  [SOT23-5]  45.95 39.42 270 bottom
U95  SN74CB3Q3257PWR  [TSSOP16_25-59_205X180]  27.32 38.4 0 bottom
U96  SN74LVC1G11DRYR  [SON6_SN74LVC2G17_40X60_0-6]  56.71 36.49 0 bottom
U97  TCA9801DGK  [VSSOP8_25-59_120X120_1-1]  64.56 36.25 180 bottom
U98  SN74AVC8T245RHL  [QFN24_19-68_220X140_1]  54.47 31.4 90 bottom
U99  TCA9801DGK  [VSSOP8_25-59_120X120_1-1]  65.43 31.03 0 bottom
U100  TCA6424ARGJR  [QFN32_19-68_200X200]  45.38 30.74 0 bottom
U101  SN74AVC8T245RHL  [QFN24_19-68_220X140_1]  37.86 30.74 270 bottom
U102  TXS0102DQER  [X2SON8_TXS0102_40X60_0-4]  61.54 27.81 180 bottom
U103  SN74LVC1G04DCKR  [SC70-5]  69.37 26.51 180 bottom
U104  TVS2200DRVR  [SON6_25-59_85X85_0-8]  10.27 26.17 90 bottom
U105  TPS79601DRBR  [SON8_25-59_130X130_1]  76.34 24.24 0 bottom
U106  TXS0102DQER  [X2SON8_TXS0102_40X60_0-4]  49.16 24.05 90 bottom
U107  SN74LVC1G32DPWR  [X2SON5_TLV7021_30X30_0-4]  46.02 23.97 0 bottom
U108  SN74LVC3G17DCUR  [VSSOP8_19-68_85X95_0-9]  39.24 20.88 90 bottom
U109  SN74AVC2T244DQMR  [X2SON8_15-74_70X50]  58.18 20.87 0 bottom
U110  SN74AVC4T245RSVR  [UQFN16_TMUX1574_70X100_0-6]  29.81 20.43 270 bottom
U111  SN74AVC4T245RSVR  [UQFN16_TMUX1574_70X100_0-6]  66.94 20.33 0 bottom
U112  TXS0102DQER  [X2SON8_TXS0102_40X60_0-4]  62.98 19.8 270 bottom
U113  93LC46B  [MSOP8_25-59_125X125_1-1]  12.29 19.66 270 bottom
U114  SN74AVC4T245RSVR  [UQFN16_TMUX1574_70X100_0-6]  48.86 19.29 270 bottom
U115  TPD4E004DRYR  [SON6_19-68_40X60_PB_0-6]  76.47 16.18 0 bottom
U116  SN74LVC1G11DRYR  [SON6_SN74LVC2G17_40X60_0-6]  32.91 16.16 90 bottom
U117  SN74LVC1G32DPWR  [X2SON5_TLV7021_30X30_0-4]  39.82 15.73 180 bottom
U118  SN74AVC4T245RSVR  [UQFN16_TMUX1574_70X100_0-6]  25.44 14.97 0 bottom
U119  SN74AVC4T245RSVR  [UQFN16_TMUX1574_70X100_0-6]  20.51 12.66 0 bottom
U120  TPS62177DQCR  [WSON10_19-68_80X120_0-8]  45.78 11.31 90 bottom
U121  TPS73533DRVR  [SON6_25-59_85X85]  10.51 10.09 180 bottom
U122  SN74AVC2T244DQMR  [X2SON8_15-74_70X50]  40.93 8.9 90 bottom
U123  SN74AVC4T245RSVR  [UQFN16_TMUX1574_70X100_0-6]  29.12 8.26 270 bottom
Y1  25.000MHz  [XTAL4_XRCGB-FM_80X60_SMD_0-7]  22.48 104.86 270 top
Y2  32.768KHz  [XTAL_ECS-32_130X60_SMD_0-9]  24.54 100.32 90 top
Y3  32.768KHz  [XTAL_ECS-32_130X60_SMD_0-9]  7.48 76.23 90 top
Y4  16.000MHz  [XTAL4_XRCGB-FM_80X60_SMD_0-7]  58.92 27.3 0 top
Y5  12.000MHz  [XTAL_ABM3_205X130_SMD_1-4]  12.32 17.46 270 top

## Library data of the parts
C1-C113 C115-C128 C130-C397 C399-C507 = CAP
C114 C129 C398 = CAP_POL
C508-C529 = CAP_NFM
D1 D2 = DIODE_ZENER_SOT23_13
D3 D7 D8 D12 D13 = DIODE_SOD323
D4 D5 D10 D11 = DIODE_TVS_DUAL
D6 = DIODE_ESD122DMXR
D9 = DIODE_SCHOTTKY
FB1-FB3 = INDUCTOR_FERRITE
FL1-FL5 FL7-FL15 = EMIFILTER_IND
J1 = CON_PMC_20X2_F_DP_TI
J2 = CON_PCI_75_2199119-4_2230
J3 = HEADER_20X2
J4 = CON_BTOB_25X2_M_4SH
J5 = CON_HDMI_19X1
J6 = CON_RJ45-14_LPJG16314A4NL
J7 = CON_USB-A_4_2SH
J8 = HEADER_14x2
J9 J10 J12 J16 = HEADER_2X1
J11 = HEADER_5X2
J13 J15 = CON_USB-C_24_1240183621
J14 = CON_AUDIOJACK4_SJ-43514-SMT
J17 J18 = CON_USB_MINI-B
J19 = HEADER_10X2_FTR-06
J20 = CON_FLEX_22X1-CF07-221D0R0
J21 = HEADER_7X2
J22 = CON_SDCARD9_MEM2075-00-140
J23 = CON_FLEX_40X1_FH12A-40S-0.5SH
L1-L3 L5 L6 L8-L11 = INDUCTOR
L4 = INDUCTOR_DLW31S: signal model: INDUCTOR_DLW31S_IND4_DLW21H_90X_90E
L7 = INDUCTOR_DLW31S
LD1-LD10 = DIODE_LED
Q1 Q4-Q7 Q9 = MOSFET_CSD17313Q2
Q2 = MOSFET_CSD17301Q5A
Q3 Q13 Q14 = MOSFET_IRLML6401TR
Q8 = NPN_BEC
Q10 Q11 = MOSFET_CSD25310Q2
Q12 = MOSFET_BSS138W
R1-R55 R57-R93 R95-R100 R102-R119 R121-R130 R133-R308 R310 R311 R314 R315 R317 R323-R342 R344-R347 R349-R355 R357-R575 = RESISTOR
R56 R312 R316 R318-R322 = RESISTOR: signal model: RESISTOR_RES0201_0-5_0E_0E
R94 R101 R120 R131 R132 R356 = RESISTOR-4TERM
R309 R343 = RESISTOR: signal model: RESISTOR_RES0201_0-5_22E_1%_22E_1%
R313 R348 = RESISTOR: signal model: RESISTOR_RES0402_0-5_0E_0E
RA1 RA2 = RESARR_ISO4: signal model: RESARR_ISO4_RESA_EXB_0201-4_0-5_0E
RA3-RA6 = RESARR_ISO4
SW1 SW4 SW5 = 7914G-1-000E _7914G
SW2 SW3 = SW16_CHS-08A
TP1-TP14 TP17-TP117 = TESTPOINT
U1 = TXS0104ERGYR_QFN14
U2 U92 U100 = TCA6424ARGJR_QFN32
U3 = TCA9406DCUR_VSSOP8
U4 = TXB0108RGYR_VQFN20
U5 = TCA9543APWR_TSSOP14
U6 U56 = OSC4_ASFL3
U7 = LMK1C1104_TSSOP8
U8 = TS3DV642-Q1_WQFN42
U9 U86 = OSC4_KC7050K
U10 U102 U106 U112 = TXS0102DQX_SON8
U11 U32 U45 U93 U94 = SN74LVC1G08DBVRE4_SOT23-5
U12 = W35N01JWTB_TFBGA24
U13 = SII9022ACNU_QFN72
U16 U29 = TMP100NA/3K_SOT23-6
U17 U25 U82-U85 = INA231_DSBGA12
U18 = AM62A-EVM_SOC_FCBGA484
U20 = TPS22918DBVR_SOT23-6
U21 = TLV7050_DSBGA4
U22 = TPD6E001RSE_UQFN10
U24 U36 U41 U42 U96 U116 = SN74LVC1G11DCKR_SC70-6
U26 = MT53D1024M32D4DT_VFBGA200
U27 = TPS6593-Q1_VQFNP56
U28 = MTFC16GAPALBH_TFBGA153
U30 = TPD3S014D_SOT23-6
U31 = TMUX154EDGSR_VSSOP10
U33 U52 U55 U95 = SN74CB3Q3257PWR_TSSOP16
U34 = W25Q80BWSNIG_SOIC8
U35 U108 = SN74LVC3G17DCUR_VSSOP8
U37 = TPS22965DSGT_WSON8
U38 = AT24C64D-MAHM-T_UDFN8
U39 = MOSFET_CSD18501Q5A
U40 U103 = SN74LVC1G04DCKR_SC70-5
U43 = TPS630701_VQFN-HR15
U44 = 74HC7014X_SOIC14
U46 U79 = TPD2E001DRLR_SOT-5
U47 = TM4C1294NCPDTT3R_TQFP128
U48 = FT4232H_LQFP64
U49 = LM4040B25IDCKR_SC70-5
U50 = TLV7103318D_WSON6
U51 = TXB0104RUTR_UQFN12
U53 = TPS22946_DSBGA6
U54 U110 U111 U114 U118 U119 U123 = SN74AVC4T245RSV_UQFN16
U57 = TPS22912CYZVR_DSBGA4
U58 = TPD12S016PW_TSSOP24
U63 U65 = TLV71318PDQNR_X2SON4
U78 = DP83867IRRGZ_VQFN48
U81 = TPS62827DMQR_VSONHR6
U87 U97 U99 = TCA9801DGK_VSSOP8
U88 = TLV320AIC3106IRGZT_VQFN48
U89 = LM5141RGET_VQFN24
U90 = TPS65988DJ_VQFN56
U91 U104 = TVS2200_WSON6
U98 U101 = SN74AVC8T245RHL_QFN24
U105 = TPS79601DRBR_SON8
U107 U117 = SN74LVC1G32_X2SON5
U109 U122 = SN74AVC2T244DQMR_X2SON8
U113 = 93LC46B_MSOP8
U115 = TPD4E004_SON6
U120 = TPS62177_WSON10
U121 = TPS73501DRVR_SON6
Y1 Y4 = CRY4_13
Y2 Y3 Y5 = CRY

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
CAP0201_0-5
  rect 0.356x0.33 smd: 1(-0.28,0) 2(0.28,0)
CAP0402_0-75
  rect 0.559x0.635 smd: 1(-0.49,0) 2(0.49,0)
CAP0402_1
  rect 0.559x0.635 smd: 1(-0.49,0) 2(0.49,0)
CAP0603_1
  rect 0.94x1.016 smd: 1(-0.8,0) 2(0.8,0)
CAP0805_1-5
  rect 0.94x1.346 smd: 1(-0.8,0) 2(0.8,0)
CAP1206_1-75
  rect 1.143x1.803 smd: 1(-1.5,0) 2(1.5,0)
CAP1206_2
  rect 1.143x1.803 smd: 1(-1.5,0) 2(1.5,0)
CAP1210_2-75
  rect 0.94x2.591 smd: 1(-1.4,0) 2(1.4,0)
CAPAE_FCASE_10-5
  rect 4.191x2.108 smd: 1(-3.7,0) 2(3.7,0)
CAPT7343D_3-25
  rect 2.362x2.438 smd: 1(-3.1,0) 2(3.1,0)
CON_19X1_10029449-001RLF_S_R_S_6-3
  rect 0.33x1.956 smd: 1(4.75,4.928) 2(4.25,4.928) 3(3.75,4.928) 4(3.25,4.928) 5(2.75,4.928) 6(2.25,4.928) 7(1.75,4.928) 8(1.25,4.928) 9(0.75,4.928) 10(0.25,4.928) 11(-0.25,4.928) 12(-0.75,4.928) 13(-1.25,4.928) 14(-1.75,4.928) 15(-2.25,4.928) 16(-2.75,4.928) 17(-3.25,4.928) 18(-3.75,4.928) 19(-4.25,4.928)
  round 2.007 hole 1.321: 20(7.25,3.928) 21(-7.25,3.928) 22(7.85,-0.972) 23(-7.85,-0.972)
CON_AV4_SJ-43514-SMT_S_R_S_5-1
  round 1.549 hole 1.676 unplated: (0,4.515) (0,-2.485)
  rect 2.819x2.007 smd: 1(3.7,-6.385)
  rect 2.819x2.819 smd: 2(3.7,5.815)
  rect 2.819x2.21 smd: 3(-3.7,-1.685) 4(3.7,-3.585)
CON_BOX2X7_3020-14-0300-00_P_S_S_10-4
  rect 1.245x4.75 smd: 1(-7.62,-2.875) 2(-7.62,2.875) 3(-5.08,-2.875) 4(-5.08,2.875) 5(-2.54,-2.875) 6(-2.54,2.875) 7(0,-2.875) 8(0,2.875) 9(2.54,-2.875) 10(2.54,2.875) 11(5.08,-2.875) 12(5.08,2.875) 13(7.62,-2.875) 14(7.62,2.875)
CON_BTOB2X25_DF40C-50DP_P_S_S_1-3
  rect 0.229x0.66 smd: 1(-4.8,-1.355) 2(-4.8,1.355) 3(-4.4,-1.355) 4(-4.4,1.355) 5(-4,-1.355) 6(-4,1.355) 7(-3.6,-1.355) 8(-3.6,1.355) 9(-3.2,-1.355) 10(-3.2,1.355) 11(-2.8,-1.355) 12(-2.8,1.355) 13(-2.4,-1.355) 14(-2.4,1.355) 15(-2,-1.355) 16(-2,1.355) 17(-1.6,-1.355) 18(-1.6,1.355) 19(-1.2,-1.355) 20(-1.2,1.355) 21(-0.8,-1.355) 22(-0.8,1.355) 23(-0.4,-1.355) 24(-0.4,1.355) 25(0,-1.355) 26(0,1.355) 27(0.4,-1.355) 28(0.4,1.355) 29(0.8,-1.355) 30(0.8,1.355) 31(1.2,-1.355) 32(1.2,1.355) 33(1.6,-1.355) 34(1.6,1.355) 35(2,-1.355) 36(2,1.355) 37(2.4,-1.355) 38(2.4,1.355) 39(2.8,-1.355) 40(2.8,1.355) 41(3.2,-1.355) 42(3.2,1.355) 43(3.6,-1.355) 44(3.6,1.355) 45(4,-1.355) 46(4,1.355) 47(4.4,-1.355) 48(4.4,1.355) 49(4.8,-1.355) 50(4.8,1.355)
  rect 0.356x0.66 smd: SH1(-5.275,-1.355) SH2(-5.275,1.355) SH3(5.275,-1.355) SH4(5.275,1.355)
CON_FLEX1X22_54548-2271_S_R_S_1-3
  rect 0.305x1.041 smd: 1(-5.25,1.901) 2(-4.75,1.901) 3(-4.25,1.901) 4(-3.75,1.901) 5(-3.25,1.901) 6(-2.75,1.901) 7(-2.25,1.901) 8(-1.75,1.901) 9(-1.25,1.901) 10(-0.75,1.901) 11(-0.25,1.901) 12(0.25,1.901) 13(0.75,1.901) 14(1.25,1.901) 15(1.75,1.901) 16(2.25,1.901) 17(2.75,1.901) 18(3.25,1.901) 19(3.75,1.901) 20(4.25,1.901) 21(4.75,1.901) 22(5.25,1.901)
  rect 1.651x1.397 smd: 23(-7.525,0.001) 24(7.525,0.001)
CON_FLEX40X1_FH12A_S_R_S
  rect 0.33x1.397 smd: 1(-9.75,3.575) 2(-9.25,3.575) 3(-8.75,3.575) 4(-8.25,3.575) 5(-7.75,3.575) 6(-7.25,3.575) 7(-6.75,3.575) 8(-6.25,3.575) 9(-5.75,3.575) 10(-5.25,3.575) 11(-4.75,3.575) 12(-4.25,3.575) 13(-3.75,3.575) 14(-3.25,3.575) 15(-2.75,3.575) 16(-2.25,3.575) 17(-1.75,3.575) 18(-1.25,3.575) 19(-0.75,3.575) 20(-0.25,3.575) 21(0.25,3.575) 22(0.75,3.575) 23(1.25,3.575) 24(1.75,3.575) 25(2.25,3.575) 26(2.75,3.575) 27(3.25,3.575) 28(3.75,3.575) 29(4.25,3.575) 30(4.75,3.575) 31(5.25,3.575) 32(5.75,3.575) 33(6.25,3.575) 34(6.75,3.575) 35(7.25,3.575) 36(7.75,3.575) 37(8.25,3.575) 38(8.75,3.575) 39(9.25,3.575) 40(9.75,3.575)
  rect 1.803x2.311 smd: 41(-11.65,0.325) 42(11.65,0.325)
CON_MINIPCI75_2199119-4_S_R_S_3-2_2230
  round 0.991 hole 1.118 unplated: (-10,-1.437)
  round 1.448 hole 1.575 unplated: (10,-1.437)
  rect 0.305x1.575 smd: 1(-9.25,3.838) 2(-9,-3.712) 3(-8.75,3.838) 4(-8.5,-3.712) 5(-8.25,3.838) 6(-8,-3.712) 7(-7.75,3.838) 8(-7.5,-3.712) 9(-7.25,3.838) 10(-7,-3.712) 11(-6.75,3.838) 12(-6.5,-3.712) 13(-6.25,3.838) 14(-6,-3.712) 15(-5.75,3.838) 16(-5.5,-3.712) 17(-5.25,3.838) 18(-5,-3.712) 19(-4.75,3.838) 20(-4.5,-3.712) 21(-4.25,3.838) 22(-4,-3.712) 23(-3.75,3.838) 32(-1.5,-3.712) 33(-1.25,3.838) 34(-1,-3.712) 35(-0.75,3.838) 36(-0.5,-3.712) 37(-0.25,3.838) 38(0,-3.712) 39(0.25,3.838) 40(0.5,-3.712) 41(0.75,3.838) 42(1,-3.712) 43(1.25,3.838) 44(1.5,-3.712) 45(1.75,3.838) 46(2,-3.712) 47(2.25,3.838) 48(2.5,-3.712) 49(2.75,3.838) 50(3,-3.712) 51(3.25,3.838) 52(3.5,-3.712) 53(3.75,3.838) 54(4,-3.712) 55(4.25,3.838) 56(4.5,-3.712) 57(4.75,3.838) 58(5,-3.712) 59(5.25,3.838) 60(5.5,-3.712) 61(5.75,3.838) 62(6,-3.712) 63(6.25,3.838) 64(6.5,-3.712) 65(6.75,3.838) 66(7,-3.712) 67(7.25,3.838) 68(7.5,-3.712) 69(7.75,3.838) 70(8,-3.712) 71(8.25,3.838) 72(8.5,-3.712) 73(8.75,3.838) 74(9,-3.712) 75(9.25,3.838)
  rect 1.219x2.769 smd: SH1(-10.35,3.063) SH2(10.35,3.063)
  round 5.309 hole 2.997: SH3(0,-30)
CON_MUSBB5_629105150521_S_R_S_2-7
  round 0.686 hole 0.813 unplated: (-2.5,1.848) (2.5,1.848)
  rect 0.457x1.295 smd: 1(-1.3,2.948) 2(-0.65,2.948) 3(0,2.948) 4(0.65,2.948) 5(1.3,2.948)
  oval 1.448x2.311 hole 0.864x1.727: 6(-3.725,2.898) 7(3.725,2.898)
  oval 1.143x1.803 hole 0.559x1.219: 8(-3.875,-0.902) 9(3.875,-0.902)
CON_PMC2X20_QSH-020-01-D-DP-A_S_S_S_3-4
  round 0.889 hole 1.016 unplated: (-10.067,2.67) (10.067,2.67)
  rect 0.279x2.261 smd: 1(-7.257,-2.87) 2(-7.257,2.87) 3(-6.756,-2.87) 4(-6.756,2.87) 5(-5.756,-2.87) 6(-5.756,2.87) 7(-5.257,-2.87) 8(-5.257,2.87) 9(-4.257,-2.87) 10(-4.257,2.87) 11(-3.756,-2.87) 12(-3.756,2.87) 13(-2.756,-2.87) 14(-2.756,2.87) 15(-2.257,-2.87) 16(-2.257,2.87) 17(-1.257,-2.87) 18(-1.257,2.87) 19(-0.756,-2.87) 20(-0.756,2.87) 21(0.244,-2.87) 22(0.244,2.87) 23(0.743,-2.87) 24(0.743,2.87) 25(1.743,-2.87) 26(1.743,2.87) 27(2.244,-2.87) 28(2.244,2.87) 29(3.244,-2.87) 30(3.244,2.87) 31(3.743,-2.87) 32(3.743,2.87) 33(4.743,-2.87) 34(4.743,2.87) 35(5.244,-2.87) 36(5.244,2.87) 37(6.244,-2.87) 38(6.244,2.87) 39(6.743,-2.87) 40(6.743,2.87)
  rect 2.54x0.432 smd: SH1(-8.065,0) SH4(8.065,0)
  rect 4.699x0.432 smd: SH2(-3.175,0) SH3(3.175,0)
CON_RJ45-14_LPJG16314A4NL_S_R_T_13-6
  round 3.073 hole 3.2 unplated: (0,-8.89) (11.43,-8.89)
  rect 1.6x1.6 hole 0.914: 1(0,0)
  round 1.6 hole 0.914: 2(1.27,-2.54) 3(2.54,0) 4(3.81,-2.54) 5(5.08,0) 6(6.35,-2.54) 7(7.62,0) 8(8.89,-2.54) 9(10.16,0) 10(11.43,-2.54)
  round 1.702 hole 1.016: 11(12.44,-11.43) 12(12.44,-13.462) 13(-1.01,-11.43) 14(-1.01,-13.462)
  round 2.362 hole 1.676: 15(-2.032,-5.842) 16(13.462,-5.842)
CON_SD9_MEM2051-00-195-00_S_R_S_2-1
  rect 0.787x1.499 smd: 1(1.94,-3.66) 2(0.84,-3.26) 3(-0.26,-3.66) 4(-1.36,-3.86) 5(-2.46,-3.66) 6(-3.56,-3.86) 7(-4.66,-3.66) 8(-5.76,-3.66)
  rect 0.991x0.94 smd: 9(-3.56,7.425)
  rect 1.397x1.905 smd: SH1(6.6,-6.95) SH2(-6.55,-5.95)
  rect 1.295x1.397 smd: SH3(0.75,7.2) SH4(-4.95,7.2)
CON_USBA4_629104151_S_R_S_7-4
  round 1.092 hole 1.219 unplated: (-2.5,2.965) (2.5,2.965)
  rect 1.194x3.2 smd: 1(-3.5,6.665) 2(-1,6.665) 3(1,6.665) 4(3.5,6.665)
  oval 1.397x3.708 hole 0.711x2.997: SH1(-6.4,3.465) SH2(6.4,3.465)
CON_USBC24_2012670_S_R_S_3-9
  rect 0.305x0.762 smd: A1(-3,4.056) A2(-2.5,4.056) A3(-2,4.056) A4(-1.5,4.056) A5(-1,4.056) A6(-0.5,4.056) A7(0.5,4.056) A8(1,4.056) A9(1.5,4.056) A10(2,4.056) A11(2.5,4.056) A12(3,4.056) B2(2.25,2.356) B3(1.75,2.356) B4(1.25,2.356) B5(0.75,2.356) B6(0.25,2.356) B7(-0.25,2.356) B8(-0.75,2.356) B9(-1.25,2.356) B10(-1.75,2.356) B11(-2.25,2.356)
  rect 0.94x0.762 smd: B1(3.05,2.356) B12(-3.05,2.356)
  oval 1.194x2.21 hole 0.61x1.575: SH1(-4.32,3.246) SH2(4.32,3.246)
  oval 1.194x3.708 hole 0.61x2.083: SH3(4.62,-2.114) SH4(-4.62,-2.114)
DIO_DFN0201_0-4
  rect 0.229x0.381 smd: 1(-0.22,0) 2(0.22,0)
DIO_DFN0402_0-5
  rect 0.356x0.61 smd: 1(-0.34,0) 2(0.34,0)
DIO_SOD323_1
  rect 0.914x0.508 smd: 1(-1.25,0) 2(1.25,0)
DSBGA4_15-74_30X30_0-5
  round 0.279 smd: A1(-0.2,0.2) A2(0.2,0.2) B1(-0.2,-0.2) B2(0.2,-0.2)
DSBGA6_19-68_40X60_0-5
  round 0.33 smd: A1(-0.25,0.5) A2(0.25,0.5) B1(-0.25,0) B2(0.25,0) C1(-0.25,-0.5) C2(0.25,-0.5)
DSBGA12_15-74_60X70_0-4
  round 0.279 smd: A1(-0.4,0.6) A2(0,0.6) A3(0.4,0.6) B1(-0.4,0.2) B2(0,0.2) B3(0.4,0.2) C1(-0.4,-0.2) C2(0,-0.2) C3(0.4,-0.2) D1(-0.4,-0.6) D2(0,-0.6) D3(0.4,-0.6)
EMIFIL_BLM15A_0402_0-6
  rect 0.61x0.61 smd: 1(-0.46,0) 2(0.46,0)
EMIFIL_BLM18P_0603_0-8
  rect 0.991x0.991 smd: 1(-0.75,0) 2(0.75,0)
EMIFIL_NFM15CC_0402_0-5
  rect 0.305x0.305 smd: 1(-0.5,0) 3(0.5,0)
  rect 0.254x0.762 smd: 2(0,0)
EMIFIL_NFM18C_0603_0-7
  rect 0.61x0.61 smd: 1(-0.8,0) 3(0.8,0)
  rect 0.406x1.219 smd: 2(0,0)
FBGA484_31-49_710X710_2-7
  round 0.457 smd: A1(-8.4,8.4) A2(-7.6,8.4) A3(-6.8,8.4) A4(-6,8.4) A5(-5.2,8.4) A6(-4.4,8.4) A7(-3.6,8.4) A8(-2.8,8.4) A9(-2,8.4) A10(-1.2,8.4) A11(-0.4,8.4) A12(0.4,8.4) A13(1.2,8.4) A14(2,8.4) A15(2.8,8.4) A16(3.6,8.4) A17(4.4,8.4) A18(5.2,8.4) A19(6,8.4) A20(6.8,8.4) A21(7.6,8.4) A22(8.4,8.4) AA1(-8.4,-7.6) AA2(-7.6,-7.6) AA3(-6.8,-7.6) AA4(-6,-7.6) AA5(-5.2,-7.6) AA6(-4.4,-7.6) AA7(-3.6,-7.6) AA8(-2.8,-7.6) AA9(-2,-7.6) AA10(-1.2,-7.6) AA11(-0.4,-7.6) AA12(0.4,-7.6) AA13(1.2,-7.6) AA14(2,-7.6) AA15(2.8,-7.6) AA16(3.6,-7.6) AA17(4.4,-7.6) AA18(5.2,-7.6) AA19(6,-7.6) AA20(6.8,-7.6) AA21(7.6,-7.6) AA22(8.4,-7.6) AB1(-8.4,-8.4) AB2(-7.6,-8.4) AB3(-6.8,-8.4) AB4(-6,-8.4) AB5(-5.2,-8.4) AB6(-4.4,-8.4) AB7(-3.6,-8.4) AB8(-2.8,-8.4) AB9(-2,-8.4) AB10(-1.2,-8.4) AB11(-0.4,-8.4) AB12(0.4,-8.4) AB13(1.2,-8.4) AB14(2,-8.4) AB15(2.8,-8.4) AB16(3.6,-8.4) AB17(4.4,-8.4) AB18(5.2,-8.4) AB19(6,-8.4) AB20(6.8,-8.4) AB21(7.6,-8.4) AB22(8.4,-8.4) B1(-8.4,7.6) B2(-7.6,7.6) B3(-6.8,7.6) B4(-6,7.6) B5(-5.2,7.6) B6(-4.4,7.6) B7(-3.6,7.6) B8(-2.8,7.6) B9(-2,7.6) B10(-1.2,7.6) B11(-0.4,7.6) B12(0.4,7.6) B13(1.2,7.6) B14(2,7.6) B15(2.8,7.6) B16(3.6,7.6) B17(4.4,7.6) B18(5.2,7.6) B19(6,7.6) B20(6.8,7.6) B21(7.6,7.6) B22(8.4,7.6) C1(-8.4,6.8) C2(-7.6,6.8) C3(-6.8,6.8) C4(-6,6.8) C5(-5.2,6.8) C6(-4.4,6.8) C7(-3.6,6.8) C8(-2.8,6.8) C9(-2,6.8) C10(-1.2,6.8) C11(-0.4,6.8) C12(0.4,6.8) C13(1.2,6.8) C14(2,6.8) C15(2.8,6.8) C16(3.6,6.8) C17(4.4,6.8) C18(5.2,6.8) C19(6,6.8) C20(6.8,6.8) C21(7.6,6.8) C22(8.4,6.8) D1(-8.4,6) D2(-7.6,6) D3(-6.8,6) D4(-6,6) D5(-5.2,6) D6(-4.4,6) D7(-3.6,6) D8(-2.8,6) D9(-2,6) D10(-1.2,6) D11(-0.4,6) D12(0.4,6) D13(1.2,6) D14(2,6) D15(2.8,6) D16(3.6,6) D17(4.4,6) D18(5.2,6) D19(6,6) D20(6.8,6) D21(7.6,6) D22(8.4,6) E1(-8.4,5.2) E2(-7.6,5.2) E3(-6.8,5.2) E4(-6,5.2) E5(-5.2,5.2) E6(-4.4,5.2) E7(-3.6,5.2) E8(-2.8,5.2) E9(-2,5.2) E10(-1.2,5.2) E11(-0.4,5.2) E12(0.4,5.2) E13(1.2,5.2) E14(2,5.2) E15(2.8,5.2) E16(3.6,5.2) E17(4.4,5.2) E18(5.2,5.2) E19(6,5.2) E20(6.8,5.2) E21(7.6,5.2) E22(8.4,5.2) F1(-8.4,4.4) F2(-7.6,4.4) F3(-6.8,4.4) F4(-6,4.4) F5(-5.2,4.4) F6(-4.4,4.4) F7(-3.6,4.4) F8(-2.8,4.4) F9(-2,4.4) F10(-1.2,4.4) F11(-0.4,4.4) F12(0.4,4.4) F13(1.2,4.4) F14(2,4.4) F15(2.8,4.4) F16(3.6,4.4) F17(4.4,4.4) F18(5.2,4.4) F19(6,4.4) F20(6.8,4.4) F21(7.6,4.4) F22(8.4,4.4) G1(-8.4,3.6) G2(-7.6,3.6) G3(-6.8,3.6) G4(-6,3.6) G5(-5.2,3.6) G6(-4.4,3.6) G7(-3.6,3.6) G8(-2.8,3.6) G9(-2,3.6) G10(-1.2,3.6) G11(-0.4,3.6) G12(0.4,3.6) G13(1.2,3.6) G14(2,3.6) G15(2.8,3.6) G16(3.6,3.6) G17(4.4,3.6) G18(5.2,3.6) G19(6,3.6) G20(6.8,3.6) G21(7.6,3.6) G22(8.4,3.6) H1(-8.4,2.8) H2(-7.6,2.8) H3(-6.8,2.8) H4(-6,2.8) H5(-5.2,2.8) H6(-4.4,2.8) H7(-3.6,2.8) H8(-2.8,2.8) H9(-2,2.8) H10(-1.2,2.8) H11(-0.4,2.8) H12(0.4,2.8) H13(1.2,2.8) H14(2,2.8) H15(2.8,2.8) H16(3.6,2.8) H17(4.4,2.8) H18(5.2,2.8) H19(6,2.8) H20(6.8,2.8) H21(7.6,2.8) H22(8.4,2.8) J1(-8.4,2) J2(-7.6,2) J3(-6.8,2) J4(-6,2) J5(-5.2,2) J6(-4.4,2) J7(-3.6,2) J8(-2.8,2) J9(-2,2) J10(-1.2,2) J11(-0.4,2) J12(0.4,2) J13(1.2,2) J14(2,2) J15(2.8,2) J16(3.6,2) J17(4.4,2) J18(5.2,2) J19(6,2) J20(6.8,2) J21(7.6,2) J22(8.4,2) K1(-8.4,1.2) K2(-7.6,1.2) K3(-6.8,1.2) K4(-6,1.2) K5(-5.2,1.2) K6(-4.4,1.2) K7(-3.6,1.2) K8(-2.8,1.2) K9(-2,1.2) K10(-1.2,1.2) K11(-0.4,1.2) K12(0.4,1.2) K13(1.2,1.2) K14(2,1.2) K15(2.8,1.2) K16(3.6,1.2) K17(4.4,1.2) K18(5.2,1.2) K19(6,1.2) K20(6.8,1.2) K21(7.6,1.2) K22(8.4,1.2) L1(-8.4,0.4) L2(-7.6,0.4) L3(-6.8,0.4) L4(-6,0.4) L5(-5.2,0.4) L6(-4.4,0.4) L7(-3.6,0.4) L8(-2.8,0.4) L9(-2,0.4) L10(-1.2,0.4) L11(-0.4,0.4) L12(0.4,0.4) L13(1.2,0.4) L14(2,0.4) L15(2.8,0.4) L16(3.6,0.4) L17(4.4,0.4) L18(5.2,0.4) L19(6,0.4) L20(6.8,0.4) L21(7.6,0.4) L22(8.4,0.4) M1(-8.4,-0.4) M2(-7.6,-0.4) M3(-6.8,-0.4) M4(-6,-0.4) M5(-5.2,-0.4) M6(-4.4,-0.4) M7(-3.6,-0.4) M8(-2.8,-0.4) M9(-2,-0.4) M10(-1.2,-0.4) M11(-0.4,-0.4) M12(0.4,-0.4) M13(1.2,-0.4) M14(2,-0.4) M15(2.8,-0.4) M16(3.6,-0.4) M17(4.4,-0.4) M18(5.2,-0.4) M19(6,-0.4) M20(6.8,-0.4) M21(7.6,-0.4) M22(8.4,-0.4) N1(-8.4,-1.2) N2(-7.6,-1.2) N3(-6.8,-1.2) N4(-6,-1.2) N5(-5.2,-1.2) N6(-4.4,-1.2) N7(-3.6,-1.2) N8(-2.8,-1.2) N9(-2,-1.2) N10(-1.2,-1.2) N11(-0.4,-1.2) N12(0.4,-1.2) N13(1.2,-1.2) N14(2,-1.2) N15(2.8,-1.2) N16(3.6,-1.2) N17(4.4,-1.2) N18(5.2,-1.2) N19(6,-1.2) N20(6.8,-1.2) N21(7.6,-1.2) N22(8.4,-1.2) P1(-8.4,-2) P2(-7.6,-2) P3(-6.8,-2) P4(-6,-2) P5(-5.2,-2) P6(-4.4,-2) P7(-3.6,-2) P8(-2.8,-2) P9(-2,-2) P10(-1.2,-2) P11(-0.4,-2) P12(0.4,-2) P13(1.2,-2) P14(2,-2) P15(2.8,-2) P16(3.6,-2) P17(4.4,-2) P18(5.2,-2) P19(6,-2) P20(6.8,-2) P21(7.6,-2) P22(8.4,-2) R1(-8.4,-2.8) R2(-7.6,-2.8) R3(-6.8,-2.8) R4(-6,-2.8) R5(-5.2,-2.8) R6(-4.4,-2.8) R7(-3.6,-2.8) R8(-2.8,-2.8) R9(-2,-2.8) R10(-1.2,-2.8) R11(-0.4,-2.8) R12(0.4,-2.8) R13(1.2,-2.8) R14(2,-2.8) R15(2.8,-2.8) R16(3.6,-2.8) R17(4.4,-2.8) R18(5.2,-2.8) R19(6,-2.8) R20(6.8,-2.8) R21(7.6,-2.8) R22(8.4,-2.8) T1(-8.4,-3.6) T2(-7.6,-3.6) T3(-6.8,-3.6) T4(-6,-3.6) T5(-5.2,-3.6) T6(-4.4,-3.6) T7(-3.6,-3.6) T8(-2.8,-3.6) T9(-2,-3.6) T10(-1.2,-3.6) T11(-0.4,-3.6) T12(0.4,-3.6) T13(1.2,-3.6) T14(2,-3.6) T15(2.8,-3.6) T16(3.6,-3.6) T17(4.4,-3.6) T18(5.2,-3.6) T19(6,-3.6) T20(6.8,-3.6) T21(7.6,-3.6) T22(8.4,-3.6) U1(-8.4,-4.4) U2(-7.6,-4.4) U3(-6.8,-4.4) U4(-6,-4.4) U5(-5.2,-4.4) U6(-4.4,-4.4) U7(-3.6,-4.4) U8(-2.8,-4.4) U9(-2,-4.4) U10(-1.2,-4.4) U11(-0.4,-4.4) U12(0.4,-4.4) U13(1.2,-4.4) U14(2,-4.4) U15(2.8,-4.4) U16(3.6,-4.4) U17(4.4,-4.4) U18(5.2,-4.4) U19(6,-4.4) U20(6.8,-4.4) U21(7.6,-4.4) U22(8.4,-4.4) V1(-8.4,-5.2) V2(-7.6,-5.2) V3(-6.8,-5.2) V4(-6,-5.2) V5(-5.2,-5.2) V6(-4.4,-5.2) V7(-3.6,-5.2) V8(-2.8,-5.2) V9(-2,-5.2) V10(-1.2,-5.2) V11(-0.4,-5.2) V12(0.4,-5.2) V13(1.2,-5.2) V14(2,-5.2) V15(2.8,-5.2) V16(3.6,-5.2) V17(4.4,-5.2) V18(5.2,-5.2) V19(6,-5.2) V20(6.8,-5.2) V21(7.6,-5.2) V22(8.4,-5.2) W1(-8.4,-6) W2(-7.6,-6) W3(-6.8,-6) W4(-6,-6) W5(-5.2,-6) W6(-4.4,-6) W7(-3.6,-6) W8(-2.8,-6) W9(-2,-6) W10(-1.2,-6) W11(-0.4,-6) W12(0.4,-6) W13(1.2,-6) W14(2,-6) W15(2.8,-6) W16(3.6,-6) W17(4.4,-6) W18(5.2,-6) W19(6,-6) W20(6.8,-6) W21(7.6,-6) W22(8.4,-6) Y1(-8.4,-6.8) Y2(-7.6,-6.8) Y3(-6.8,-6.8) Y4(-6,-6.8) Y5(-5.2,-6.8) Y6(-4.4,-6.8) Y7(-3.6,-6.8) Y8(-2.8,-6.8) Y9(-2,-6.8) Y10(-1.2,-6.8) Y11(-0.4,-6.8) Y12(0.4,-6.8) Y13(1.2,-6.8) Y14(2,-6.8) Y15(2.8,-6.8) Y16(3.6,-6.8) Y17(4.4,-6.8) Y18(5.2,-6.8) Y19(6,-6.8) Y20(6.8,-6.8) Y21(7.6,-6.8) Y22(8.4,-6.8)
HDR_1X2_90120-0122_S_T_5-6
  rect 1.702x1.702 hole 1.016: 1(0,0)
  round 1.702 hole 1.016: 2(-2.54,0)
HDR_1X2_61300211121_S_T_8-6
  rect 1.803x1.803 hole 1.118: 1(0,0)
  round 1.803 hole 1.118: 2(-2.54,0)
HDR_2X5_PEC05DAAN_S_T_8-6
  rect 1.702x1.702 hole 1.016: 1(0,0)
  round 1.702 hole 1.016: 2(0,2.54) 3(2.54,0) 4(2.54,2.54) 5(5.08,0) 6(5.08,2.54) 7(7.62,0) 8(7.62,2.54) 9(10.16,0) 10(10.16,2.54)
HDR_2X10_FTR-110-51-D-06_S_S_8-7
  rect 0.711x3.124 smd: 1(-5.715,-2.578) 2(-5.715,2.578) 3(-4.445,-2.578) 4(-4.445,2.578) 5(-3.175,-2.578) 7(-1.905,-2.578) 8(-1.905,2.578) 9(-0.635,-2.578) 10(-0.635,2.578) 11(0.635,-2.578) 12(0.635,2.578) 13(1.905,-2.578) 14(1.905,2.578) 15(3.175,-2.578) 16(3.175,2.578) 17(4.445,-2.578) 18(4.445,2.578) 19(5.715,-2.578) 20(5.715,2.578)
HDR_2X20_PEC20DAAN_S_T_8-6
  rect 1.702x1.702 hole 1.016: 1(0,0)
  round 1.702 hole 1.016: 2(0,2.54) 3(2.54,0) 4(2.54,2.54) 5(5.08,0) 6(5.08,2.54) 7(7.62,0) 8(7.62,2.54) 9(10.16,0) 10(10.16,2.54) 11(12.7,0) 12(12.7,2.54) 13(15.24,0) 14(15.24,2.54) 15(17.78,0) 16(17.78,2.54) 17(20.32,0) 18(20.32,2.54) 19(22.86,0) 20(22.86,2.54) 21(25.4,0) 22(25.4,2.54) 23(27.94,0) 24(27.94,2.54) 25(30.48,0) 26(30.48,2.54) 27(33.02,0) 28(33.02,2.54) 29(35.56,0) 30(35.56,2.54) 31(38.1,0) 32(38.1,2.54) 33(40.64,0) 34(40.64,2.54) 35(43.18,0) 36(43.18,2.54) 37(45.72,0) 38(45.72,2.54) 39(48.26,0) 40(48.26,2.54)
HDR_14X2_100_S_T
  rect 1.6x1.6 hole 0.914: 1(0,0)
  round 1.6 hole 0.914: 2(0,-2.54) 3(-2.54,0) 4(-2.54,-2.54) 5(-5.08,0) 6(-5.08,-2.54) 7(-7.62,0) 8(-7.62,-2.54) 9(-10.16,0) 10(-10.16,-2.54) 11(-12.7,0) 12(-12.7,-2.54) 13(-15.24,0) 14(-15.24,-2.54) 15(-17.78,0) 16(-17.78,-2.54) 17(-20.32,0) 18(-20.32,-2.54) 19(-22.86,0) 20(-22.86,-2.54) 21(-25.4,0) 22(-25.4,-2.54) 23(-27.94,0) 24(-27.94,-2.54) 25(-30.48,0) 26(-30.48,-2.54) 27(-33.02,0) 28(-33.02,-2.54)
IND4_DLW21H_90X60_SMD_1-4
  rect 0.889x0.356 smd: 1(-0.85,-0.425) 2(0.85,-0.425) 3(0.85,0.425) 4(-0.85,0.425)
IND0603
  rect 0.914x1.016 smd: 1(-0.8,0) 2(0.8,0)
IND0806_1-2
  rect 1.219x1.803 smd: 1(-0.85,0) 2(0.85,0)
IND1008_1-2
  rect 1.194x2.21 smd: 1(-1.1,0) 2(1.1,0)
IND_1277AS-H_130X110_SMD_1-2
  rect 0.762x2.489 smd: 1(-1.225,0) 2(1.225,0)
IND_XAL7070_300X310_SMD_7
  rect 1.93x6.502 smd: 1(-2.41,0) 2(2.41,0)
IND_XFL4020_170X170_SMD_2-1
  rect 0.991x3.404 smd: 1(-1.185,0) 2(1.185,0)
LED_150040GS73220_40X20_SMD_0-4
  rect 0.406x0.457 smd: 1(-0.5,0) 2(0.5,0)
LED_150080VS75000_80X50_SMD_0-8
  rect 1.092x1.194 smd: 1(-1.05,0) 2(1.05,0)
LQFP64_19-68_390X390_1-6
  rect 1.499x0.305 smd: 1(-5.7,3.75) 2(-5.7,3.25) 3(-5.7,2.75) 4(-5.7,2.25) 5(-5.7,1.75) 6(-5.7,1.25) 7(-5.7,0.75) 8(-5.7,0.25) 9(-5.7,-0.25) 10(-5.7,-0.75) 11(-5.7,-1.25) 12(-5.7,-1.75) 13(-5.7,-2.25) 14(-5.7,-2.75) 15(-5.7,-3.25) 16(-5.7,-3.75) 33(5.7,-3.75) 34(5.7,-3.25) 35(5.7,-2.75) 36(5.7,-2.25) 37(5.7,-1.75) 38(5.7,-1.25) 39(5.7,-0.75) 40(5.7,-0.25) 41(5.7,0.25) 42(5.7,0.75) 43(5.7,1.25) 44(5.7,1.75) 45(5.7,2.25) 46(5.7,2.75) 47(5.7,3.25) 48(5.7,3.75)
  rect 0.305x1.499 smd: 17(-3.75,-5.7) 18(-3.25,-5.7) 19(-2.75,-5.7) 20(-2.25,-5.7) 21(-1.75,-5.7) 22(-1.25,-5.7) 23(-0.75,-5.7) 24(-0.25,-5.7) 25(0.25,-5.7) 26(0.75,-5.7) 27(1.25,-5.7) 28(1.75,-5.7) 29(2.25,-5.7) 30(2.75,-5.7) 31(3.25,-5.7) 32(3.75,-5.7) 49(3.75,5.7) 50(3.25,5.7) 51(2.75,5.7) 52(2.25,5.7) 53(1.75,5.7) 54(1.25,5.7) 55(0.75,5.7) 56(0.25,5.7) 57(-0.25,5.7) 58(-0.75,5.7) 59(-1.25,5.7) 60(-1.75,5.7) 61(-2.25,5.7) 62(-2.75,5.7) 63(-3.25,5.7) 64(-3.75,5.7)
MSOP8_25-59_125X125_1-1
  rect 1.448x0.457 smd: 1(-2.2,0.975) 2(-2.2,0.325) 3(-2.2,-0.325) 4(-2.2,-0.975) 5(2.2,-0.975) 6(2.2,-0.325) 7(2.2,0.325) 8(2.2,0.975)
MSOP10_19-68_120X120_1-1
  rect 1.448x0.305 smd: 1(-2.2,1) 2(-2.2,0.5) 3(-2.2,0) 4(-2.2,-0.5) 5(-2.2,-1) 6(2.2,-1) 7(2.2,-0.5) 8(2.2,0) 9(2.2,0.5) 10(2.2,1)
OSC4_ECS-327MVATX-2_100X80_SMD_1
  rect 1.092x0.889 smd: 1(-0.9,-0.7) 2(0.9,-0.7) 3(0.9,0.7) 4(-0.9,0.7)
OSC4_ECS-2520MV_100X80_SMD_0-9
  rect 0.889x0.787 smd: 1(-0.925,-0.725) 2(0.925,-0.725) 3(0.925,0.725) 4(-0.925,0.725)
OSC4_KC2016K_80X60_SMD_0-8
  rect 0.61x0.813 smd: 1(-0.9,-0.6) 2(0.9,-0.6) 3(0.9,0.6) 4(-0.9,0.6)
QFN14_19-68_145X145
  rect 0.838x0.279 smd: 1(-1.725,-0.75) 7(1.725,-0.75) 8(1.725,0.75) 14(-1.725,0.75)
  rect 0.279x0.838 smd: 2(-1,-1.725) 3(-0.5,-1.725) 4(0,-1.725) 5(0.5,-1.725) 6(1,-1.725) 9(1,1.725) 10(0.5,1.725) 11(0,1.725) 12(-0.5,1.725) 13(-1,1.725)
  custom 0.512x0.512 smd: 15(0,0)
QFN20_19-68_185X145_1
  rect 0.864x0.279 smd: 1(-2.225,-0.75) 10(2.225,-0.75) 11(2.225,0.75) 20(-2.225,0.75)
  rect 0.279x0.864 smd: 2(-1.75,-1.725) 3(-1.25,-1.725) 4(-0.75,-1.725) 5(-0.25,-1.725) 6(0.25,-1.725) 7(0.75,-1.725) 8(1.25,-1.725) 9(1.75,-1.725) 12(1.75,1.725) 13(1.25,1.725) 14(0.75,1.725) 15(0.25,1.725) 16(-0.25,1.725) 17(-0.75,1.725) 18(-1.25,1.725) 19(-1.75,1.725)
  rect 3.15x2.159 smd: 21(0,0)
QFN24_19-68_220X140_1
  rect 0.838x0.279 smd: 1(-2.725,-0.75) 12(2.725,-0.75) 13(2.725,0.75) 24(-2.725,0.75)
  rect 0.279x0.838 smd: 2(-2.25,-1.725) 3(-1.75,-1.725) 4(-1.25,-1.725) 5(-0.75,-1.725) 6(-0.25,-1.725) 7(0.25,-1.725) 8(0.75,-1.725) 9(1.25,-1.725) 10(1.75,-1.725) 11(2.25,-1.725) 14(2.25,1.725) 15(1.75,1.725) 16(1.25,1.725) 17(0.75,1.725) 18(0.25,1.725) 19(-0.25,1.725) 20(-0.75,1.725) 21(-1.25,1.725) 22(-1.75,1.725) 23(-2.25,1.725)
  custom 0.508x0.508 smd: 25(0,0)
QFN32_19-68_200X200
  rect 0.838x0.305 smd: 1(-2.5,1.75) 2(-2.5,1.25) 3(-2.5,0.75) 4(-2.5,0.25) 5(-2.5,-0.25) 6(-2.5,-0.75) 7(-2.5,-1.25) 8(-2.5,-1.75) 17(2.5,-1.75) 18(2.5,-1.25) 19(2.5,-0.75) 20(2.5,-0.25) 21(2.5,0.25) 22(2.5,0.75) 23(2.5,1.25) 24(2.5,1.75)
  rect 0.305x0.838 smd: 9(-1.75,-2.5) 10(-1.25,-2.5) 11(-0.75,-2.5) 12(-0.25,-2.5) 13(0.25,-2.5) 14(0.75,-2.5) 15(1.25,-2.5) 16(1.75,-2.5) 25(1.75,2.5) 26(1.25,2.5) 27(0.75,2.5) 28(0.25,2.5) 29(-0.25,2.5) 30(-0.75,2.5) 31(-1.25,2.5) 32(-1.75,2.5)
  rect 3.556x3.556 smd: 33(0,0)
QFN48_19-68_280X280_1
  rect 0.813x0.305 smd: 1(-3.5,2.75) 2(-3.5,2.25) 3(-3.5,1.75) 4(-3.5,1.25) 5(-3.5,0.75) 6(-3.5,0.25) 7(-3.5,-0.25) 8(-3.5,-0.75) 9(-3.5,-1.25) 10(-3.5,-1.75) 11(-3.5,-2.25) 12(-3.5,-2.75) 25(3.5,-2.75) 26(3.5,-2.25) 27(3.5,-1.75) 28(3.5,-1.25) 29(3.5,-0.75) 30(3.5,-0.25) 31(3.5,0.25) 32(3.5,0.75) 33(3.5,1.25) 34(3.5,1.75) 35(3.5,2.25) 36(3.5,2.75)
  rect 0.305x0.813 smd: 13(-2.75,-3.5) 14(-2.25,-3.5) 15(-1.75,-3.5) 16(-1.25,-3.5) 17(-0.75,-3.5) 18(-0.25,-3.5) 19(0.25,-3.5) 20(0.75,-3.5) 21(1.25,-3.5) 22(1.75,-3.5) 23(2.25,-3.5) 24(2.75,-3.5) 37(2.75,3.5) 38(2.25,3.5) 39(1.75,3.5) 40(1.25,3.5) 41(0.75,3.5) 42(0.25,3.5) 43(-0.25,3.5) 44(-0.75,3.5) 45(-1.25,3.5) 46(-1.75,3.5) 47(-2.25,3.5) 48(-2.75,3.5)
  rect 5.639x5.639 smd: 49(0,0)
