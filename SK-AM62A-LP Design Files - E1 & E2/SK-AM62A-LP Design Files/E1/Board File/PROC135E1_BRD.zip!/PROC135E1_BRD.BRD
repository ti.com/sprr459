# Allegro board PROC135E1_BRD.BRD (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
QFN72_19-68_390X390_0-9
  rect 0.838x0.254 smd: 1(-4.95,4.25) 2(-4.95,3.75) 3(-4.95,3.25) 4(-4.95,2.75) 5(-4.95,2.25) 6(-4.95,1.75) 7(-4.95,1.25) 8(-4.95,0.75) 9(-4.95,0.25) 10(-4.95,-0.25) 11(-4.95,-0.75) 12(-4.95,-1.25) 13(-4.95,-1.75) 14(-4.95,-2.25) 15(-4.95,-2.75) 16(-4.95,-3.25) 17(-4.95,-3.75) 18(-4.95,-4.25) 37(4.95,-4.25) 38(4.95,-3.75) 39(4.95,-3.25) 40(4.95,-2.75) 41(4.95,-2.25) 42(4.95,-1.75) 43(4.95,-1.25) 44(4.95,-0.75) 45(4.95,-0.25) 46(4.95,0.25) 47(4.95,0.75) 48(4.95,1.25) 49(4.95,1.75) 50(4.95,2.25) 51(4.95,2.75) 52(4.95,3.25) 53(4.95,3.75) 54(4.95,4.25)
  rect 0.254x0.838 smd: 19(-4.25,-4.95) 20(-3.75,-4.95) 21(-3.25,-4.95) 22(-2.75,-4.95) 23(-2.25,-4.95) 24(-1.75,-4.95) 25(-1.25,-4.95) 26(-0.75,-4.95) 27(-0.25,-4.95) 28(0.25,-4.95) 29(0.75,-4.95) 30(1.25,-4.95) 31(1.75,-4.95) 32(2.25,-4.95) 33(2.75,-4.95) 34(3.25,-4.95) 35(3.75,-4.95) 36(4.25,-4.95) 55(4.25,4.95) 56(3.75,4.95) 57(3.25,4.95) 58(2.75,4.95) 59(2.25,4.95) 60(1.75,4.95) 61(1.25,4.95) 62(0.75,4.95) 63(0.25,4.95) 64(-0.25,4.95) 65(-0.75,4.95) 66(-1.25,4.95) 67(-1.75,4.95) 68(-2.25,4.95) 69(-2.75,4.95) 70(-3.25,4.95) 71(-3.75,4.95) 72(-4.25,4.95)
  rect 4.851x4.851 smd: 73(0,0)
RES0201_0-5
  rect 0.356x0.33 smd: 1(-0.28,0) 2(0.28,0)
RES0402_0-5
  rect 0.559x0.635 smd: 1(-0.49,0) 2(0.49,0)
RES0603_0-75
  rect 0.635x0.991 smd: 1(-0.74,0) 2(0.74,0)
RES0805_0-75
  rect 1.194x1.448 smd: 1(-0.95,0) 2(0.95,0)
RES1206_1
  rect 1.067x1.753 smd: 1(-1.45,0) 2(1.45,0)
RES_CST0612_0612-4_0-9
  rect 0.991x2.311 smd: 1(-0.85,0.6) 4(0.85,0.6)
  rect 0.991x0.787 smd: 2(-0.85,-1.35) 3(0.85,-1.35)
RES_KRL3216T4_1206-4_0-7
  rect 1.143x0.356 smd: 1(-0.775,1.5) 4(0.775,1.5)
  rect 1.143x2.692 smd: 2(-0.775,-0.325) 3(0.775,-0.325)
RESA_EXB_0201-4_0-5
  rect 0.203x0.305 smd: 1(-0.6,-0.275) 2(-0.2,-0.275) 3(0.2,-0.275) 4(0.6,-0.275) 5(0.6,0.275) 6(0.2,0.275) 7(-0.2,0.275) 8(-0.6,0.275)
SC70-5
  rect 0.94x0.406 smd: 1(-1.1,0.65) 2(-1.1,0) 3(-1.1,-0.65) 4(1.1,-0.65) 5(1.1,0.65)
SC70-5_1-1
  rect 0.94x0.406 smd: 1(-1.1,0.65) 2(-1.1,0) 3(-1.1,-0.65) 4(1.1,-0.65) 5(1.1,0.65)
SOIC8_1-8
  rect 1.549x0.61 smd: 1(-2.7,1.905) 2(-2.7,0.635) 3(-2.7,-0.635) 4(-2.7,-1.905) 5(2.7,-1.905) 6(2.7,-0.635) 7(2.7,0.635) 8(2.7,1.905)
SON6_19-68_40X60_PB_0-6
  rect 0.356x0.305 smd: 1(-0.3,0.5) 2(-0.3,0) 3(-0.3,-0.5) 4(0.3,-0.5) 5(0.3,0) 6(0.3,0.5)
SON6_25-59_85X85
  rect 0.61x0.356 smd: 1(-1.05,0.65) 2(-1.05,0) 3(-1.05,-0.65) 4(1.05,-0.65) 5(1.05,0) 6(1.05,0.65)
  rect 1.092x1.702 smd: 7(0,0)
SON6_25-59_85X85_0-8
  rect 0.61x0.356 smd: 1(-1.05,0.65) 2(-1.05,0) 3(-1.05,-0.65) 4(1.05,-0.65) 5(1.05,0) 6(1.05,0.65)
  rect 1.067x1.702 smd: 7(0,0)
SON6_CSD17313Q2_80X80
  rect 0.406x0.457 smd: 1(-0.65,-0.923) 2(0,-0.923) 3(0.65,-0.923) 4(0.65,0.923) 5(0,0.923) 6(-0.65,0.923)
  rect 0.406x0.864 smd: 7(0.65,0.096)
  rect 1.041x1.092 smd: 8(-0.325,0)
SON6_SN74LVC2G17_40X60_0-6
  rect 0.356x0.203 smd: 1(-0.275,0.5)
  rect 0.305x0.203 smd: 2(-0.3,0) 3(-0.3,-0.5) 4(0.3,-0.5) 5(0.3,0) 6(0.3,0.5)
SON8_25-59_130X130_1
  rect 0.762x0.356 smd: 1(-1.45,0.975) 2(-1.45,0.325) 3(-1.45,-0.325) 4(-1.45,-0.975) 5(1.45,-0.975) 6(1.45,-0.325) 7(1.45,0.325) 8(1.45,0.975)
  rect 1.753x2.515 smd: 9(0,0)
SOT23-5
  rect 0.889x0.559 smd: 1(-1.2,0.95) 2(-1.2,0) 3(-1.2,-0.95) 4(1.2,-0.95) 5(1.2,0.95)
SOT23-6
  rect 1.041x0.61 smd: 1(-1.35,0.95) 2(-1.35,0) 3(-1.35,-0.95) 4(1.35,-0.95) 5(1.35,0) 6(1.35,0.95)
SOT23-6_1-5
  rect 1.092x0.61 smd: 1(-1.35,0.95) 2(-1.35,0) 3(-1.35,-0.95) 4(1.35,-0.95) 5(1.35,0) 6(1.35,0.95)
SOT23-123_1-2
  rect 1.016x0.61 smd: 1(-1.15,0.95) 2(-1.15,-0.95) 3(1.15,0)
SOT553-5_0-6
  rect 0.559x0.229 smd: 1(-0.69,0.5) 2(-0.69,0) 3(-0.69,-0.5) 4(0.69,-0.5) 5(0.69,0.5)
SW4_100X216_200X200_SMD_4-2
  rect 1.27x1.27 smd: 1(-1.27,-2.75) 2(1.27,-2.75) 3(1.27,2.75) 4(-1.27,2.75)
SW16_416131160808_460X230_SMD_2-7
  rect 0.762x1.27 smd: 1(-4.445,-3.81) 2(-3.175,-3.81) 3(-1.905,-3.81) 4(-0.635,-3.81) 5(0.635,-3.81) 6(1.905,-3.81) 7(3.175,-3.81) 8(4.445,-3.81) 9(4.445,3.81) 10(3.175,3.81) 11(1.905,3.81) 12(0.635,3.81) 13(-0.635,3.81) 14(-1.905,3.81) 15(-3.175,3.81) 16(-4.445,3.81)
TO_SOT23-123
  rect 1.016x1.397 smd: 1(-0.95,-1.1) 2(0.95,-1.1) 3(0,1.1)
TP20_SMD
  round 0.457 smd: 1(0,0)
TP30_SMD
  round 0.762 smd: 1(0,0)
TP40_SMD
  round 1.016 smd: 1(0,0)
TP_40X65
  round 1.651 hole 1.016: 1(0,0)
TPBGA24_39-37_240X320_1-2
  round 0.356 smd: A2(-1,2) A3(0,2) A4(1,2) A5(2,2) B1(-2,1) B2(-1,1) B3(0,1) B4(1,1) B5(2,1) C1(-2,0) C2(-1,0) C3(0,0) C4(1,0) C5(2,0) D1(-2,-1) D2(-1,-1) D3(0,-1) D4(1,-1) D5(2,-1) E1(-2,-2) E2(-1,-2) E3(0,-2) E4(1,-2) E5(2,-2)
TQFN42_19-68_140X360_0-8
  rect 0.813x0.305 smd: 1(-1.7,4) 2(-1.7,3.5) 3(-1.7,3) 4(-1.7,2.5) 5(-1.7,2) 6(-1.7,1.5) 7(-1.7,1) 8(-1.7,0.5) 9(-1.7,0) 10(-1.7,-0.5) 11(-1.7,-1) 12(-1.7,-1.5) 13(-1.7,-2) 14(-1.7,-2.5) 15(-1.7,-3) 16(-1.7,-3.5) 17(-1.7,-4) 22(1.7,-4) 23(1.7,-3.5) 24(1.7,-3) 25(1.7,-2.5) 26(1.7,-2) 27(1.7,-1.5) 28(1.7,-1) 29(1.7,-0.5) 30(1.7,0) 31(1.7,0.5) 32(1.7,1) 33(1.7,1.5) 34(1.7,2) 35(1.7,2.5) 36(1.7,3) 37(1.7,3.5) 38(1.7,4)
  rect 0.305x0.813 smd: 18(-0.75,-4.45) 19(-0.25,-4.45) 20(0.25,-4.45) 21(0.75,-4.45) 39(0.75,4.45) 40(0.25,4.45) 41(-0.25,4.45) 42(-0.75,4.45)
  rect 2.159x7.645 smd: 43(0,0)
TQFP128_15-74_550X550_1-2
  rect 1.499x0.203 smd: 1(-7.7,6.2) 2(-7.7,5.8) 3(-7.7,5.4) 4(-7.7,5) 5(-7.7,4.6) 6(-7.7,4.2) 7(-7.7,3.8) 8(-7.7,3.4) 9(-7.7,3) 10(-7.7,2.6) 11(-7.7,2.2) 12(-7.7,1.8) 13(-7.7,1.4) 14(-7.7,1) 15(-7.7,0.6) 16(-7.7,0.2) 17(-7.7,-0.2) 18(-7.7,-0.6) 19(-7.7,-1) 20(-7.7,-1.4) 21(-7.7,-1.8) 22(-7.7,-2.2) 23(-7.7,-2.6) 24(-7.7,-3) 25(-7.7,-3.4) 26(-7.7,-3.8) 27(-7.7,-4.2) 28(-7.7,-4.6) 29(-7.7,-5) 30(-7.7,-5.4) 31(-7.7,-5.8) 32(-7.7,-6.2) 65(7.7,-6.2) 66(7.7,-5.8) 67(7.7,-5.4) 68(7.7,-5) 69(7.7,-4.6) 70(7.7,-4.2) 71(7.7,-3.8) 72(7.7,-3.4) 73(7.7,-3) 74(7.7,-2.6) 75(7.7,-2.2) 76(7.7,-1.8) 77(7.7,-1.4) 78(7.7,-1) 79(7.7,-0.6) 80(7.7,-0.2) 81(7.7,0.2) 82(7.7,0.6) 83(7.7,1) 84(7.7,1.4) 85(7.7,1.8) 86(7.7,2.2) 87(7.7,2.6) 88(7.7,3) 89(7.7,3.4) 90(7.7,3.8) 91(7.7,4.2) 92(7.7,4.6) 93(7.7,5) 94(7.7,5.4) 95(7.7,5.8) 96(7.7,6.2)
  rect 0.203x1.499 smd: 33(-6.2,-7.7) 34(-5.8,-7.7) 35(-5.4,-7.7) 36(-5,-7.7) 37(-4.6,-7.7) 38(-4.2,-7.7) 39(-3.8,-7.7) 40(-3.4,-7.7) 41(-3,-7.7) 42(-2.6,-7.7) 43(-2.2,-7.7) 44(-1.8,-7.7) 45(-1.4,-7.7) 46(-1,-7.7) 47(-0.6,-7.7) 48(-0.2,-7.7) 49(0.2,-7.7) 50(0.6,-7.7) 51(1,-7.7) 52(1.4,-7.7) 53(1.8,-7.7) 54(2.2,-7.7) 55(2.6,-7.7) 56(3,-7.7) 57(3.4,-7.7) 58(3.8,-7.7) 59(4.2,-7.7) 60(4.6,-7.7) 61(5,-7.7) 62(5.4,-7.7) 63(5.8,-7.7) 64(6.2,-7.7) 97(6.2,7.7) 98(5.8,7.7) 99(5.4,7.7) 100(5,7.7) 101(4.6,7.7) 102(4.2,7.7) 103(3.8,7.7) 104(3.4,7.7) 105(3,7.7) 106(2.6,7.7) 107(2.2,7.7) 108(1.8,7.7) 109(1.4,7.7) 110(1,7.7) 111(0.6,7.7) 112(0.2,7.7) 113(-0.2,7.7) 114(-0.6,7.7) 115(-1,7.7) 116(-1.4,7.7) 117(-1.8,7.7) 118(-2.2,7.7) 119(-2.6,7.7) 120(-3,7.7) 121(-3.4,7.7) 122(-3.8,7.7) 123(-4.2,7.7) 124(-4.6,7.7) 125(-5,7.7) 126(-5.4,7.7) 127(-5.8,7.7) 128(-6.2,7.7)
TSSOP8_25-59_125X180_1-2
  rect 1.499x0.457 smd: 1(-2.9,0.975) 2(-2.9,0.325) 3(-2.9,-0.325) 4(-2.9,-0.975) 5(2.9,-0.975) 6(2.9,-0.325) 7(2.9,0.325) 8(2.9,0.975)
TSSOP14_25-59_205X180_1-2
  rect 1.6x0.356 smd: 1(-2.8,1.95) 2(-2.8,1.3) 3(-2.8,0.65) 4(-2.8,0) 5(-2.8,-0.65) 6(-2.8,-1.3) 7(-2.8,-1.95) 8(2.8,-1.95) 9(2.8,-1.3) 10(2.8,-0.65) 11(2.8,0) 12(2.8,0.65) 13(2.8,1.3) 14(2.8,1.95)
TSSOP16_25-59_205X180
  rect 1.6x0.356 smd: 1(-2.8,2.275) 2(-2.8,1.625) 3(-2.8,0.975) 4(-2.8,0.325) 5(-2.8,-0.325) 6(-2.8,-0.975) 7(-2.8,-1.625) 8(-2.8,-2.275) 9(2.8,-2.275) 10(2.8,-1.625) 11(2.8,-0.975) 12(2.8,-0.325) 13(2.8,0.325) 14(2.8,0.975) 15(2.8,1.625) 16(2.8,2.275)
TSSOP24_25-59_315X180_1-2
  rect 1.448x0.457 smd: 1(-2.9,3.575) 2(-2.9,2.925) 3(-2.9,2.275) 4(-2.9,1.625) 5(-2.9,0.975) 6(-2.9,0.325) 7(-2.9,-0.325) 8(-2.9,-0.975) 9(-2.9,-1.625) 10(-2.9,-2.275) 11(-2.9,-2.925) 12(-2.9,-3.575) 13(2.9,-3.575) 14(2.9,-2.925) 15(2.9,-2.275) 16(2.9,-1.625) 17(2.9,-0.975) 18(2.9,-0.325) 19(2.9,0.325) 20(2.9,0.975) 21(2.9,1.625) 22(2.9,2.275) 23(2.9,2.925) 24(2.9,3.575)
TVSOP14_15-74_180X150_1-2
  rect 1.499x0.203 smd: 1(-2.9,1.2) 2(-2.9,0.8) 3(-2.9,0.4) 4(-2.9,0) 5(-2.9,-0.4) 6(-2.9,-0.8) 7(-2.9,-1.2) 8(2.9,-1.2) 9(2.9,-0.8) 10(2.9,-0.4) 11(2.9,0) 12(2.9,0.4) 13(2.9,0.8) 14(2.9,1.2)
UDFN8_19-68_120X80_0-6
  rect 0.813x0.305 smd: 1(-1.45,0.75) 2(-1.45,0.25) 3(-1.45,-0.25) 4(-1.45,-0.75) 5(1.45,-0.75) 6(1.45,-0.25) 7(1.45,0.25) 8(1.45,0.75)
  rect 1.397x1.6 smd: 9(0,0)
unnamed
  round 2.616 hole 2.743 unplated: (0,0)
unnamed#3
  round 1.6 hole 1.727 unplated: (-10.362,10.362) (-10.362,-10.362) (10.362,10.362) (10.362,-10.362)
  round 0.737 hole 0.864 unplated: (-10.362,-5.282) (10.362,7.822)
UQFN10_19-68_80X60_0-6
  rect 0.584x0.305 smd: 1(-0.635,0.75) 4(-0.635,-0.75) 6(0.635,-0.75) 9(0.635,0.75)
  rect 0.584x0.254 smd: 2(-0.635,0.25) 3(-0.635,-0.25) 7(0.635,-0.25) 8(0.635,0.25)
  rect 0.305x0.635 smd: 5(0,-0.86) 10(0,0.86)
UQFN12_TXB0104RUT_70X80_0-6
  custom 0.102x0.102 smd: 1(-0.65,0.8)
  rect 0.61x0.203 smd: 2(-0.65,0.4) 3(-0.65,0) 4(-0.65,-0.4) 5(-0.65,-0.8) 7(0.65,-0.8) 8(0.65,-0.4) 9(0.65,0) 10(0.65,0.4) 11(0.65,0.8)
  rect 0.203x0.61 smd: 6(0,-0.8) 12(0,0.8)
UQFN16_TMUX1574_70X100_0-6
  rect 0.711x0.203 smd: 1(-0.75,0.6)
  rect 0.61x0.203 smd: 2(-0.8,0.2) 3(-0.8,-0.2) 4(-0.8,-0.6) 9(0.8,-0.6) 10(0.8,-0.2) 11(0.8,0.2) 12(0.8,0.6)
  rect 0.203x0.61 smd: 5(-0.6,-1.2) 6(-0.2,-1.2) 7(0.2,-1.2) 8(0.6,-1.2) 13(0.6,1.2) 14(0.2,1.2) 15(-0.2,1.2) 16(-0.6,1.2)
VFBGA153_19-68_460X520_1-1
  round 0.203 smd: A1(-3.25,3.25) A2(-2.75,3.25) A3(-2.25,3.25) A4(-1.75,3.25) A5(-1.25,3.25) A6(-0.75,3.25) B1(-3.25,2.75) C1(-3.25,2.25) D1(-3.25,1.75) M1(-3.25,-2.25) N1(-3.25,-2.75) P1(-3.25,-3.25)
  round 0.254 smd: A7(-0.25,3.25) A8(0.25,3.25) A9(0.75,3.25) A10(1.25,3.25) A11(1.75,3.25) A12(2.25,3.25) A13(2.75,3.25) A14(3.25,3.25) B2(-2.75,2.75) B3(-2.25,2.75) B4(-1.75,2.75) B5(-1.25,2.75) B6(-0.75,2.75) B7(-0.25,2.75) B8(0.25,2.75) B9(0.75,2.75) B10(1.25,2.75) B11(1.75,2.75) B12(2.25,2.75) B13(2.75,2.75) B14(3.25,2.75) C2(-2.75,2.25) C3(-2.25,2.25) C4(-1.75,2.25) C5(-1.25,2.25) C6(-0.75,2.25) C7(-0.25,2.25) C8(0.25,2.25) C9(0.75,2.25) C10(1.25,2.25) C11(1.75,2.25) C12(2.25,2.25) C13(2.75,2.25) C14(3.25,2.25) D2(-2.75,1.75) D3(-2.25,1.75) D4(-1.75,1.75) D12(2.25,1.75) D13(2.75,1.75) D14(3.25,1.75) E1(-3.25,1.25) E2(-2.75,1.25) E3(-2.25,1.25) E5(-1.25,1.25) E6(-0.75,1.25) E7(-0.25,1.25) E8(0.25,1.25) E9(0.75,1.25) E10(1.25,1.25) E12(2.25,1.25) E13(2.75,1.25) E14(3.25,1.25) F1(-3.25,0.75) F2(-2.75,0.75) F3(-2.25,0.75) F5(-1.25,0.75) F10(1.25,0.75) F12(2.25,0.75) F13(2.75,0.75) F14(3.25,0.75) G1(-3.25,0.25) G2(-2.75,0.25) G3(-2.25,0.25) G5(-1.25,0.25) G10(1.25,0.25) G12(2.25,0.25) G13(2.75,0.25) G14(3.25,0.25) H1(-3.25,-0.25) H2(-2.75,-0.25) H3(-2.25,-0.25) H5(-1.25,-0.25) H10(1.25,-0.25) H12(2.25,-0.25) H13(2.75,-0.25) H14(3.25,-0.25) J1(-3.25,-0.75) J2(-2.75,-0.75) J3(-2.25,-0.75) J5(-1.25,-0.75) J10(1.25,-0.75) J12(2.25,-0.75) J13(2.75,-0.75) J14(3.25,-0.75) K1(-3.25,-1.25) K2(-2.75,-1.25) K3(-2.25,-1.25) K5(-1.25,-1.25) K6(-0.75,-1.25) K7(-0.25,-1.25) K8(0.25,-1.25) K9(0.75,-1.25) K10(1.25,-1.25) K12(2.25,-1.25) K13(2.75,-1.25) K14(3.25,-1.25) L1(-3.25,-1.75) L2(-2.75,-1.75) L3(-2.25,-1.75) L12(2.25,-1.75) L13(2.75,-1.75) L14(3.25,-1.75) M2(-2.75,-2.25) M3(-2.25,-2.25) M4(-1.75,-2.25) M5(-1.25,-2.25) M6(-0.75,-2.25) M7(-0.25,-2.25) M8(0.25,-2.25) M9(0.75,-2.25) M10(1.25,-2.25) M11(1.75,-2.25) M12(2.25,-2.25) M13(2.75,-2.25) M14(3.25,-2.25) N2(-2.75,-2.75) N3(-2.25,-2.75) N4(-1.75,-2.75) N5(-1.25,-2.75) N6(-0.75,-2.75) N7(-0.25,-2.75) N8(0.25,-2.75) N9(0.75,-2.75) N10(1.25,-2.75) N11(1.75,-2.75) N12(2.25,-2.75) N13(2.75,-2.75) N14(3.25,-2.75) P2(-2.75,-3.25) P3(-2.25,-3.25) P4(-1.75,-3.25) P5(-1.25,-3.25) P6(-0.75,-3.25) P7(-0.25,-3.25) P8(0.25,-3.25) P9(0.75,-3.25) P10(1.25,-3.25) P11(1.75,-3.25) P12(2.25,-3.25) P13(2.75,-3.25) P14(3.25,-3.25)
VQFN24_LM5141_160X160_1
  rect 0.61x0.254 smd: 1(-1.9,1.25) 2(-1.9,0.75) 3(-1.9,0.25) 4(-1.9,-0.25) 5(-1.9,-0.75) 6(-1.9,-1.25) 13(1.9,-1.25) 14(1.9,-0.75) 15(1.9,-0.25) 16(1.9,0.25) 17(1.9,0.75) 18(1.9,1.25)
  rect 0.254x0.61 smd: 7(-1.25,-1.9) 8(-0.75,-1.9) 9(-0.25,-1.9) 10(0.25,-1.9) 11(0.75,-1.9) 12(1.25,-1.9) 19(1.25,1.9) 20(0.75,1.9) 21(0.25,1.9) 22(-0.25,1.9) 23(-0.75,1.9) 24(-1.25,1.9)
  rect 2.794x2.794 smd: 25(0,0)
  custom 0.145x0.145 smd: A1(-1.72,1.72) A2(-1.72,-1.72) A3(1.72,-1.72) A4(1.72,1.72)
VQFN48_19-68_285X285
  rect 0.864x0.305 smd: 1(-3.5,2.75) 2(-3.5,2.25) 3(-3.5,1.75) 4(-3.5,1.25) 5(-3.5,0.75) 6(-3.5,0.25) 7(-3.5,-0.25) 8(-3.5,-0.75) 9(-3.5,-1.25) 10(-3.5,-1.75) 11(-3.5,-2.25) 12(-3.5,-2.75) 25(3.5,-2.75) 26(3.5,-2.25) 27(3.5,-1.75) 28(3.5,-1.25) 29(3.5,-0.75) 30(3.5,-0.25) 31(3.5,0.25) 32(3.5,0.75) 33(3.5,1.25) 34(3.5,1.75) 35(3.5,2.25) 36(3.5,2.75)
  rect 0.305x0.864 smd: 13(-2.75,-3.5) 14(-2.25,-3.5) 15(-1.75,-3.5) 16(-1.25,-3.5) 17(-0.75,-3.5) 18(-0.25,-3.5) 19(0.25,-3.5) 20(0.75,-3.5) 21(1.25,-3.5) 22(1.75,-3.5) 23(2.25,-3.5) 24(2.75,-3.5) 37(2.75,3.5) 38(2.25,3.5) 39(1.75,3.5) 40(1.25,3.5) 41(0.75,3.5) 42(0.25,3.5) 43(-0.25,3.5) 44(-0.75,3.5) 45(-1.25,3.5) 46(-1.75,3.5) 47(-2.25,3.5) 48(-2.75,3.5)
  rect 4.166x4.166 smd: 49(0,0)
VQFN56_19-68_320X320_0-9_EP6
  rect 0.787x0.305 smd: 1(-4,3.25) 2(-4,2.75) 3(-4,2.25) 4(-4,1.75) 5(-4,1.25) 6(-4,0.75) 7(-4,0.25) 8(-4,-0.25) 9(-4,-0.75) 10(-4,-1.25) 11(-4,-1.75) 12(-4,-2.25) 13(-4,-2.75) 14(-4,-3.25) 29(4,-3.25) 30(4,-2.75) 31(4,-2.25) 32(4,-1.75) 33(4,-1.25) 34(4,-0.75) 35(4,-0.25) 36(4,0.25) 37(4,0.75) 38(4,1.25) 39(4,1.75) 40(4,2.25) 41(4,2.75) 42(4,3.25)
  rect 0.305x0.787 smd: 15(-3.25,-4) 16(-2.75,-4) 17(-2.25,-4) 18(-1.75,-4) 19(-1.25,-4) 20(-0.75,-4) 21(-0.25,-4) 22(0.25,-4) 23(0.75,-4) 24(1.25,-4) 25(1.75,-4) 26(2.25,-4) 27(2.75,-4) 28(3.25,-4) 43(3.25,4) 44(2.75,4) 45(2.25,4) 46(1.75,4) 47(1.25,4) 48(0.75,4) 49(0.25,4) 50(-0.25,4) 51(-0.75,4) 52(-1.25,4) 53(-1.75,4) 54(-2.25,4) 55(-2.75,4) 56(-3.25,4)
  rect 5.994x5.994 smd: 57(0,0)
VQFN56_TPS65987D_280X280_1
  rect 0.813x0.711 smd: 1(-3.35,2.4) 3(-3.35,1.6) 11(-3.35,-1.6) 13(-3.35,-2.4)
  rect 0.711x0.203 smd: 5(-3.35,1) 6(-3.35,0.6) 7(-3.35,0.2) 8(-3.35,-0.2) 9(-3.35,-0.6) 10(-3.35,-1) 29(3.35,-2.6) 30(3.35,-2.2) 31(3.35,-1.8) 32(3.35,-1.4) 33(3.35,-1) 34(3.35,-0.6) 35(3.35,-0.2) 36(3.35,0.2) 37(3.35,0.6) 38(3.35,1) 39(3.35,1.4) 40(3.35,1.8) 41(3.35,2.2) 42(3.35,2.6)
  rect 0.203x0.711 smd: 15(-2.6,-3.35) 16(-2.2,-3.35) 17(-1.8,-3.35) 18(-1.4,-3.35) 19(-1,-3.35) 20(-0.6,-3.35) 21(-0.2,-3.35) 22(0.2,-3.35) 23(0.6,-3.35) 24(1,-3.35) 25(1.4,-3.35) 26(1.8,-3.35) 27(2.2,-3.35) 28(2.6,-3.35) 43(2.6,3.35) 44(2.2,3.35) 45(1.8,3.35) 46(1.4,3.35) 47(1,3.35) 48(0.6,3.35) 49(0.2,3.35) 50(-0.2,3.35) 51(-0.6,3.35) 52(-1,3.35) 53(-1.4,3.35) 54(-1.8,3.35) 55(-2.2,3.35) 56(-2.6,3.35)
  rect 1.753x2.591 smd: 57(-1.875,1.45)
  rect 1.753x2.54 smd: 58(-1.875,-1.475)
  rect 3.404x5.512 smd: 59(1.05,0)
VQFNHR15_TPS630701_100X120_1
  rect 0.61x0.254 smd: 1(-1.15,0.75) 2(-1.15,0.25) 3(-1.15,-0.25) 4(-1.15,-0.75)
  rect 0.254x0.61 smd: 5(-0.725,-1.4) 6(-0.225,-1.4) 14(-0.225,1.4) 15(-0.725,1.4)
  rect 0.838x0.711 smd: 7(0.525,-1.4) 12(0.525,1.4)
  rect 1.448x0.356 smd: 9(0.775,-0.5) 11(0.775,0.5)
  rect 1.803x0.356 smd: 10(0.6,0)
VSON8_CSD173_130X130
  rect 0.635x0.483 smd: 1(-1.435,0.975) 2(-1.435,0.325) 3(-1.435,-0.325) 4(-1.435,-0.975)
  custom 0.577x0.577 smd: 5(0.595,0)
VSON8_CSD173_130X130_1-1
  rect 0.635x0.483 smd: 1(-1.435,0.975) 2(-1.435,0.325) 3(-1.435,-0.325) 4(-1.435,-0.975)
  custom 0.577x0.577 smd: 5(0.595,0)
VSONHR6_TPS62826_60X60_1
  rect 0.711x0.356 smd: 1(-0.65,0.5) 2(-0.65,0) 3(-0.65,-0.5)
  rect 0.991x0.203 smd: 4(0.45,-0.5) 5(0.45,0) 6(0.45,0.5)
VSSOP8_19-68_85X95
  rect 0.838x0.305 smd: 1(-1.55,0.75) 2(-1.55,0.25) 3(-1.55,-0.25) 4(-1.55,-0.75) 5(1.55,-0.75) 6(1.55,-0.25) 7(1.55,0.25) 8(1.55,0.75)
VSSOP8_19-68_85X95_0-9
  rect 0.838x0.305 smd: 1(-1.55,0.75) 2(-1.55,0.25) 3(-1.55,-0.25) 4(-1.55,-0.75) 5(1.55,-0.75) 6(1.55,-0.25) 7(1.55,0.25) 8(1.55,0.75)
VSSOP8_25-59_120X120_1-1
  rect 1.397x0.457 smd: 1(-2.2,0.975) 2(-2.2,0.325) 3(-2.2,-0.325) 4(-2.2,-0.975) 5(2.2,-0.975) 6(2.2,-0.325) 7(2.2,0.325) 8(2.2,0.975)
WFBGA200_MT53E2G32D4DE_400X570_1-2
  round 0.33 smd: A1(-4.4,6.825) A2(-3.6,6.825) A3(-2.8,6.825) A4(-2,6.825) A5(-1.2,6.825) A8(1.2,6.825) A9(2,6.825) A10(2.8,6.825) A11(3.6,6.825) A12(4.4,6.825) AA1(-4.4,-6.175) AA2(-3.6,-6.175) AA3(-2.8,-6.175) AA4(-2,-6.175) AA5(-1.2,-6.175) AA8(1.2,-6.175) AA9(2,-6.175) AA10(2.8,-6.175) AA11(3.6,-6.175) AA12(4.4,-6.175) AB1(-4.4,-6.825) AB2(-3.6,-6.825) AB3(-2.8,-6.825) AB4(-2,-6.825) AB5(-1.2,-6.825) AB8(1.2,-6.825) AB9(2,-6.825) AB10(2.8,-6.825) AB11(3.6,-6.825) AB12(4.4,-6.825) B1(-4.4,6.175) B2(-3.6,6.175) B3(-2.8,6.175) B4(-2,6.175) B5(-1.2,6.175) B8(1.2,6.175) B9(2,6.175) B10(2.8,6.175) B11(3.6,6.175) B12(4.4,6.175) C1(-4.4,5.525) C2(-3.6,5.525) C3(-2.8,5.525) C4(-2,5.525) C5(-1.2,5.525) C8(1.2,5.525) C9(2,5.525) C10(2.8,5.525) C11(3.6,5.525) C12(4.4,5.525) D1(-4.4,4.875) D2(-3.6,4.875) D3(-2.8,4.875) D4(-2,4.875) D5(-1.2,4.875) D8(1.2,4.875) D9(2,4.875) D10(2.8,4.875) D11(3.6,4.875) D12(4.4,4.875) E1(-4.4,4.225) E2(-3.6,4.225) E3(-2.8,4.225) E4(-2,4.225) E5(-1.2,4.225) E8(1.2,4.225) E9(2,4.225) E10(2.8,4.225) E11(3.6,4.225) E12(4.4,4.225) F1(-4.4,3.575) F2(-3.6,3.575) F3(-2.8,3.575) F4(-2,3.575) F5(-1.2,3.575) F8(1.2,3.575) F9(2,3.575) F10(2.8,3.575) F11(3.6,3.575) F12(4.4,3.575) G1(-4.4,2.925) G2(-3.6,2.925) G3(-2.8,2.925) G4(-2,2.925) G5(-1.2,2.925) G8(1.2,2.925) G9(2,2.925) G10(2.8,2.925) G11(3.6,2.925) G12(4.4,2.925) H1(-4.4,2.275) H2(-3.6,2.275) H3(-2.8,2.275) H4(-2,2.275) H5(-1.2,2.275) H8(1.2,2.275) H9(2,2.275) H10(2.8,2.275) H11(3.6,2.275) H12(4.4,2.275) J1(-4.4,1.625) J2(-3.6,1.625) J3(-2.8,1.625) J4(-2,1.625) J5(-1.2,1.625) J8(1.2,1.625) J9(2,1.625) J10(2.8,1.625) J11(3.6,1.625) J12(4.4,1.625) K1(-4.4,0.975) K2(-3.6,0.975) K3(-2.8,0.975) K4(-2,0.975) K5(-1.2,0.975) K8(1.2,0.975) K9(2,0.975) K10(2.8,0.975) K11(3.6,0.975) K12(4.4,0.975) N1(-4.4,-0.975) N2(-3.6,-0.975) N3(-2.8,-0.975) N4(-2,-0.975) N5(-1.2,-0.975) N8(1.2,-0.975) N9(2,-0.975) N10(2.8,-0.975) N11(3.6,-0.975) N12(4.4,-0.975) P1(-4.4,-1.625) P2(-3.6,-1.625) P3(-2.8,-1.625) P4(-2,-1.625) P5(-1.2,-1.625) P8(1.2,-1.625) P9(2,-1.625) P10(2.8,-1.625) P11(3.6,-1.625) P12(4.4,-1.625) R1(-4.4,-2.275) R2(-3.6,-2.275) R3(-2.8,-2.275) R4(-2,-2.275) R5(-1.2,-2.275) R8(1.2,-2.275) R9(2,-2.275) R10(2.8,-2.275) R11(3.6,-2.275) R12(4.4,-2.275) T1(-4.4,-2.925) T2(-3.6,-2.925) T3(-2.8,-2.925) T4(-2,-2.925) T5(-1.2,-2.925) T8(1.2,-2.925) T9(2,-2.925) T10(2.8,-2.925) T11(3.6,-2.925) T12(4.4,-2.925) U1(-4.4,-3.575) U2(-3.6,-3.575) U3(-2.8,-3.575) U4(-2,-3.575) U5(-1.2,-3.575) U8(1.2,-3.575) U9(2,-3.575) U10(2.8,-3.575) U11(3.6,-3.575) U12(4.4,-3.575) V1(-4.4,-4.225) V2(-3.6,-4.225) V3(-2.8,-4.225) V4(-2,-4.225) V5(-1.2,-4.225) V8(1.2,-4.225) V9(2,-4.225) V10(2.8,-4.225) V11(3.6,-4.225) V12(4.4,-4.225) W1(-4.4,-4.875) W2(-3.6,-4.875) W3(-2.8,-4.875) W4(-2,-4.875) W5(-1.2,-4.875) W8(1.2,-4.875) W9(2,-4.875) W10(2.8,-4.875) W11(3.6,-4.875) W12(4.4,-4.875) Y1(-4.4,-5.525) Y2(-3.6,-5.525) Y3(-2.8,-5.525) Y4(-2,-5.525) Y5(-1.2,-5.525) Y8(1.2,-5.525) Y9(2,-5.525) Y10(2.8,-5.525) Y11(3.6,-5.525) Y12(4.4,-5.525)
WSON6_19-68_60X60
  rect 0.965x0.305 smd: 1(-0.65,0.5) 2(-0.65,0) 3(-0.65,-0.5) 4(0.65,-0.5) 5(0.65,0) 6(0.65,0.5)
WSON6_CSD13202Q2_80X80_0-8
  rect 0.457x0.305 smd: 1(-0.975,0.65) 2(-0.975,0) 3(-0.975,-0.65) 4(0.975,-0.65) 5(0.975,0) 6(0.975,0.65)
  rect 0.762x0.305 smd: 7(0.095,-0.65)
  rect 0.991x0.94 smd: 8(0,0.325)
WSON8_19-68_80X80_0-8
  rect 0.711x0.305 smd: 1(-1.05,0.75) 2(-1.05,0.25) 3(-1.05,-0.25) 4(-1.05,-0.75) 5(1.05,-0.75) 6(1.05,-0.25) 7(1.05,0.25) 8(1.05,0.75)
  rect 0.965x1.702 smd: 9(0,0)
WSON10_19-68_80X120_0-8
  rect 0.711x0.305 smd: 1(-1.05,1) 2(-1.05,0.5) 3(-1.05,0) 4(-1.05,-0.5) 5(-1.05,-1) 6(1.05,-1) 7(1.05,-0.5) 8(1.05,0) 9(1.05,0.5) 10(1.05,1)
  rect 0.94x2.489 smd: 11(0,0)
X2SON3_ESD122DMX_30X40_0-4
  rect 0.203x0.203 smd: 1(-0.15,0) 2(0.15,-0.34) 3(0.15,0.34)
X2SON4_TLV71318P_40X40_0-4
  custom 0.077x0.077 smd: 1(-0.43,0.325) 2(-0.43,-0.325) 3(0.43,-0.325) 4(0.43,0.325)
  rect 0.584x0.584 smd rot 135: 5(0,0)
X2SON5_TLV7021_30X30_0-4
  custom 0.08x0.08 smd: 1(-0.39,0.24) 2(-0.39,-0.24) 4(0.39,-0.24) 5(0.39,0.24)
  rect 0.356x0.356 smd rot 135: 3(0,0)
X2SON8_15-74_70X50
  rect 0.838x0.203 smd: 1(-0.55,0.6) 2(-0.55,0.2) 3(-0.55,-0.2) 4(-0.55,-0.6) 5(0.55,-0.6) 6(0.55,-0.2) 7(0.55,0.2) 8(0.55,0.6)
X2SON8_TXS0102_40X60_0-4
  rect 0.61x0.178 smd: 1(-0.4,0.525)
  rect 0.508x0.178 smd: 2(-0.45,0.175) 3(-0.45,-0.175) 4(-0.45,-0.525) 5(0.45,-0.525) 6(0.45,-0.175) 7(0.45,0.175) 8(0.45,0.525)
XTAL4_XRCGB-FM_80X60_SMD_0-7
  rect 0.762x0.711 smd: 1(-0.675,-0.5) 2(0.675,-0.5) 3(0.675,0.5) 4(-0.675,0.5)
XTAL_ABM3_205X130_SMD_1-4
  rect 1.803x2.413 smd: 1(-1.9,0) 2(1.9,0)
XTAL_ECS-32_130X60_SMD_0-9
  rect 1.118x1.905 smd: 1(-1.25,0) 2(1.25,0)

## Nets
DGND: C1.1 C2.2 C3.1 C4.2 C5.1 C6.1 C7.2 C8.2 C9.1 C10.1 C11.1 C12.1 C13.1 C14.1 C15.1 C16.1 C17.1 C18.2 C19.2 C20.1 C21.2 C22.2 C23.2 C24.2 C25.1 C26.1 C27.2 C28.2 C29.2 C30.2 C31.2 C32.2 C33.1 C35.1 C36.1 C37.2 C38.2 C39.2 C40.2 C41.2 C42.2 C43.2 C44.2 C45.2 C46.2 C47.2 C48.2 C49.2 C50.2 C51.2 C52.1 C53.1 C54.2 C55.2 C56.2 C57.1 C58.2 C59.2 C60.2 C61.2 C62.2 C63.2 C64.1 C65.2 C66.1 C67.2 C68.2 C70.2 C71.2 C72.2 C73.2 C74.2 C75.2 C76.2 C77.2 C78.2 C79.1 C80.1 C81.2 C82.2 C83.2 C84.2 C85.1 C86.2 C87.1 C88.1 C89.1 C90.1 C91.2 C92.2 C93.2 C94.2 C95.2 C96.2 C97.2 C98.2 C99.2 C100.2 C101.2 C102.2 C103.1 C104.2 C105.2 C106.1 C107.1 C108.2 C109.1 C110.1 C111.2 C112.1 C113.2 C114.2 C115.2 C116.2 C117.2 C118.2 C119.2 C120.2 C121.1 C122.2 C123.1 C124.2 C125.2 C126.2 C127.2 C128.2 C129.2 C130.2 C131.2 C132.2 C133.2 C134.1 C135.1 C136.2 C137.1 C138.2 C139.2 C140.2 C141.2 C142.2 C143.1 C144.1 C145.1 C146.1 C147.1 C148.2 C149.2 C150.2 C151.2 C152.1 C153.2 C154.2 C155.2 C156.2 C157.1 C158.1 C159.1 C160.1 C161.2 C162.1 C163.1 C164.2 C165.1 C166.2 C167.2 C168.2 C169.2 C170.2 C171.2 C172.1 C173.1 C174.1 C175.2 C176.1 C177.2 C178.1 C179.2 C180.1 C181.2 C182.2 C183.1 C184.2 C185.1 C186.2 C187.2 C188.1 C189.1 C190.2 C191.2 C192.2 C193.2 C194.2 C195.2 C196.2 C197.2 C198.2 C199.2 C200.2 C201.2 C202.2 C203.2 C204.2 C205.2 C206.2 C207.2 C208.2 C209.2 C210.2 C211.2 C212.2 C213.1 C214.2 C215.2 C216.2 C217.2 C218.2 C219.2 C220.2 C221.2 C222.2 C223.2 C224.2 C225.2 C226.2 C227.2 C228.2 C229.2 C230.2 C231.2 C232.2 C233.2 C234.2 C235.2 C236.2 C237.2 C238.2 C239.2 C240.2 C241.2 C242.2 C243.2 C244.2 C245.2 C246.2 C247.2 C248.2 C249.2 C250.2 C251.2 C252.2 C253.2 C254.2 C255.2 C256.2 C257.2 C258.2 C259.2 C260.2 C261.2 C262.2 C263.2 C264.2 C265.2 C266.2 C267.2 C268.2 C269.2 C270.2 C271.2 C272.2 C273.2 C274.2 C275.2 C276.2 C277.2 C278.2 C279.2 C280.2 C281.2 C282.2 C283.2 C284.2 C285.2 C286.2 C287.2 C288.2 C289.2 C290.2 C291.2 C292.2 C293.2 C294.2 C295.2 C296.2 C297.2 C298.2 C299.2 C300.2 C301.2 C302.2 C303.2 C304.2 C305.2 C306.2 C307.1 C308.1 C309.2 C310.2 C311.2 C312.2 C313.2 C314.1 C315.2 C316.1 C317.2 C318.2 C319.2 C320.2 C321.2 C322.2 C323.2 C324.2 C325.2 C326.2 C328.2 C329.2 C330.2 C331.2 C332.2 C333.2 C334.2 C335.2 C336.2 C337.2 C338.1 C339.2 C340.2 C341.2 C342.2 C343.2 C344.2 C345.2 C346.2 C347.2 C348.2 C349.2 C350.2 C351.2 C352.2 C353.2 C354.2 C355.2 C356.2 C357.2 C358.2 C359.2 C360.2 C361.2 C362.2 C363.2 C364.2 C365.2 C366.2 C367.2 C368.2 C369.1 C370.2 C371.2 C372.2 C373.2 C374.2 C375.1 C376.2 C377.2 C378.2 C379.2 C380.2 C381.2 C382.2 C383.2 C384.2 C386.2 C387.2 C388.2 C389.1 C390.2 C391.2 C395.2 C396.2 C397.2 C398.2 C399.2 C400.2 C401.1 C402.2 C403.2 C404.1 C405.1 C406.2 C407.2 C408.2 C409.2 C410.2 C411.2 C413.2 C415.2 C417.2 C418.2 C419.2 C420.2 C421.1 C422.2 C423.2 C424.2 C425.2 C427.2 C428.2 C429.2 C432.2 C433.2 C434.2 C435.1 C436.2 C437.1 C438.2 C439.1 C440.2 C441.1 C442.1 C443.2 C446.2 C447.2 C448.2 C449.2 C450.2 C451.1 C452.1 C453.1 C454.1 C456.2 C457.1 C459.1 C460.1 C461.2 C462.1 C463.1 C464.1 C465.1 C466.1 C467.1 C468.1 C469.2 C470.2 C471.1 C472.1 C473.1 C474.2 C475.1 C476.1 C477.1 C478.1 C479.1 C480.2 C481.1 C482.1 C483.1 C484.1 C485.1 C486.1 C487.1 C488.1 C489.2 C490.1 C491.1 C492.2 C493.1 C494.1 C495.1 C496.1 C497.2 C498.1 C499.1 C500.2 C501.1 C502.1 C503.1 C504.1 C505.2 C506.1 C507.2 C508.2(GND) C509.2(GND) C510.2(GND) C511.2(GND) C512.2(GND) C513.2(GND) C514.2(GND) C515.2(GND) C516.2(GND) C517.2(GND) C518.2(GND) C519.2(GND) C520.2(GND) C521.2(GND) C522.2(GND) C523.2(GND) C524.2(GND) C525.2(GND) C526.2(GND) C527.2(GND) C528.2(GND) C529.2(GND) D1.1(A) D2.1(A) D3.1 D4.2(ANODE) D5.2(ANODE) D6.1(GND) D7.1 D8.1 D10.2(ANODE) D11.2(ANODE) D12.1 D13.1 FL2.1 J1.12 J1.16 J1.24 J1.SH1 J1.SH2 J1.SH3 J1.SH4 J2.1(GND#1) J2.7(GND#7) J2.18(GND#18) J2.33(GND#33) J2.39(GND#39) J2.45(GND#45) J2.51(GND#51) J2.57(GND#57) J2.63(GND#63) J2.69(GND#69) J2.75(GND#75) J2.SH1 J2.SH2 J3.6 J3.9 J3.14 J3.20 J3.25 J3.34 J4.1 J4.8 J4.13 J4.14 J4.19 J4.20 J4.24 J4.25 J4.32 J4.37 J4.41 J4.SH1 J4.SH2 J4.SH3 J4.SH4 J5.2 J5.5 J5.8 J5.11 J5.17 J6.1(CH-GND) J7.4(GND) J8.2 J8.3 J8.7 J8.9 J8.14 J8.15 J8.20 J8.27 J9.2 J11.2 J11.10 J13.A1(GND#A1) J13.A12(GND#A12) J13.B1(GND#B1) J13.B12(GND#B12) J14.4 J15.A1(GND#A1) J15.A12(GND#A12) J15.B1(GND#B1) J15.B12(GND#B12) J17.5(GND) J18.5(GND) J19.10 J19.12 J19.16 J19.20 J20.1 J20.4 J20.7 J20.10 J20.13 J20.16 J20.19 J20.23 J20.24 J21.1 J21.3 J21.5 J21.7 J21.8 J21.10 J21.11 J21.13 J22.6(VSS) J22.SH1 J22.SH2 J22.SH3 J22.SH4 J23.7 J23.16 J23.25 J23.34 J23.40 J23.41 J23.42 LD3.1(CATHODE) LD4.1(CATHODE) LD6.1(CATHODE) LD9.1(CATHODE) LD10.1(CATHODE) Q1.4(S1) Q1.7(S2) Q2.1(1S) Q2.2(2S) Q2.3(3S) Q3.3(D) Q4.4(S1) Q4.7(S2) Q5.4(S1) Q5.7(S2) Q6.4(S1) Q6.7(S2) Q7.4(S1) Q7.7(S2) Q8.2(EMITTER) Q9.4(S1) Q9.7(S2) Q12.2(S) Q13.3(D) Q14.3(D) R5.1 R7.1 R12.1 R14.1 R15.2 R18.1 R21.1 R36.1 R47.2 R48.1 R54.2 R63.2 R64.2 R77.1 R93.1 R96.1 R104.2 R121.2 R129.2 R141.2 R144.1 R152.2 R153.2 R154.2 R155.2 R156.2 R157.2 R159.1 R164.1 R174.2 R177.1 R180.2 R184.2 R185.2 R186.2 R187.2 R188.2 R189.2 R190.2 R191.2 R192.2 R193.2 R195.2 R221.1 R225.1 R226.1 R227.1 R229.1 R230.1 R231.1 R232.2 R238.2 R242.2 R245.2 R251.2 R253.1 R255.2 R256.1 R271.1 R283.1 R284.1 R286.1 R305.2 R307.1 R308.2 R311.2 R314.2 R315.2 R324.1 R328.1 R331.2 R332.2 R333.1 R334.1 R336.1 R337.1 R338.2 R340.1 R344.2 R345.2 R349.2 R350.1 R351.2 R357.2 R368.2 R371.2 R389.2 R400.1 R413.1 R423.2 R424.2 R429.2 R430.2 R432.1 R440.2 R442.1 R445.2 R450.1 R452.1 R453.2 R455.2 R456.2 R457.2 R458.2 R459.2 R460.2 R461.2 R462.2 R463.1 R469.2 R471.1 R473.1 R487.2 R489.2 R491.1 R492.1 R495.1 R497.1 R511.2 R517.1 R520.1 R521.1 R524.1 R526.2 R540.1 R553.1 R560.1 R567.1 R568.1 SW1.1 SW1.4 SW4.1 SW4.4 SW5.1 SW5.4 TP8.1(TP) TP64.1(TP) TP110.1(TP) TP111.1(TP) TP112.1(TP) TP113.1(TP) TP114.1(TP) TP115.1(TP) TP116.1(TP) TP117.1(TP) U1.7(GND) U1.15(TAB) U2.25(GND) U2.33(EP) U3.2(GND) U4.11(GND) U4.21(PAD) U5.7(GND) U6.2(GND) U7.4(GND) U8.43(EP) U9.2(CASEGND) U10.4(GND) U11.3(GND) U12.B3(GND) U12.C1(VSSQ#C1) U12.E5(VSSQ#E5) U13.43(CGND) U13.55(RSVDL) U13.57(IOGND) U13.63(AGND) U13.70(VDDQ) U13.73(PAD) U16.2(GND) U17.B3(A0) U17.C1(GND) U18.A1(VSS#A1) U18.A4(VSS#A4) U18.A6(VSS#A6) U18.A10(VSS#A10) U18.A13(VSS#A13) U18.A18(VSS#A18) U18.A22(VSS#A22) U18.AA2(VSS#AA2) U18.AA4(VSS#AA4) U18.AA8(VSS#AA8) U18.AA11(VSS#AA11) U18.AA14(VSS#AA14) U18.AB1(VSS#AB1) U18.AB3(VSS#AB3) U18.AB5(VSS#AB5) U18.AB9(VSS#AB9) U18.AB12(VSS#AB12) U18.AB15(VSS#AB15) U18.AB18(VSS#AB18) U18.AB22(VSS#AB22) U18.B3(VSS#B3) U18.B5(VSS#B5) U18.B7(VSS#B7) U18.C4(VSS#C4) U18.D2(VSS#D2) U18.D4(VSS#D4) U18.D11(VSS#D11) U18.D20(VSS#D20) U18.E1(VSS#E1) U18.E3(VSS#E3) U18.E5(VSS#E5) U18.F2(VSS#F2) U18.F4(VSS#F4) U18.F11(VSS#F11) U18.F13(VSS#F13) U18.F16(VSS#F16) U18.G3(VSS#G3) U18.G5(VSS#G5) U18.G9(VSS#G9) U18.G12(VSS#G12) U18.G17(VSS#G17) U18.H1(VSS#H1) U18.H4(VSS#H4) U18.H11(VSS#H11) U18.H14(VSS#H14) U18.H20(VSS#H20) U18.J3(VSS#J3) U18.J12(VSS#J12) U18.J17(VSS#J17) U18.K1(VSS#K1) U18.K4(VSS#K4) U18.K7(VSS#K7) U18.K9(VSS#K9) U18.K11(VSS#K11) U18.L3(VSS#L3) U18.L12(VSS#L12) U18.L14(VSS#L14) U18.L20(VSS#L20) U18.M4(VSS#M4) U18.M7(VSS#M7) U18.M11(VSS#M11) U18.M17(VSS#M17) U18.N1(VSS#N1) U18.N8(VSS#N8) U18.N10(VSS#N10) U18.N12(VSS#N12) U18.N14(VSS#N14) U18.N16(VSS#N16) U18.P7(VSS#P7) U18.P11(VSS#P11) U18.P13(VSS#P13) U18.P15(VSS#P15) U18.P17(VSS#P17) U18.P20(VSS#P20) U18.R2(VSS#R2) U18.R4(VSS#R4) U18.R6(VSS#R6) U18.R10(VSS#R10) U18.R12(VSS#R12) U18.R14(VSS#R14) U18.R16(VSS#R16) U18.T1(VSS#T1) U18.T3(VSS#T3) U18.T5(VSS#T5) U18.T7(VSS#T7) U18.T15(VSS#T15) U18.T17(VSS#T17) U18.U2(VSS#U2) U18.U4(VSS#U4) U18.U6(VSS#U6) U18.U9(VSS#U9) U18.U12(VSS#U12) U18.U14(VSS#U14) U18.U16(VSS#U16) U18.V1(VSS#V1) U18.V3(VSS#V3) U18.V5(VSS#V5) U18.V7(VSS#V7) U18.V9(VSS#V9) U18.V20(VSS#V20) U18.W2(VSS#W2) U18.W4(VSS#W4) U18.W6(VSS#W6) U18.W8(VSS#W8) U18.W11(VSS#W11) U18.W14(VSS#W14) U18.Y3(VSS#Y3) U18.Y5(VSS#Y5) U18.Y9(VSS#Y9) U18.Y12(VSS#Y12) U18.Y15(VSS#Y15) U20.2(GND) U21.A1(GND) U22.5(GND) U24.2(GND) U25.B3(A0) U25.C1(GND) U25.C3(A1) U26.A3(VSS#A3) U26.A10(VSS#A10) U26.AB3(VSS#AB3) U26.AB5(VSS#AB5) U26.AB8(VSS#AB8) U26.AB10(VSS#AB10) U26.C1(VSS#C1) U26.C5(VSS#C5) U26.C8(VSS#C8) U26.C12(VSS#C12) U26.D2(VSS#D2) U26.D4(VSS#D4) U26.D9(VSS#D9) U26.D11(VSS#D11) U26.E1(VSS#E1) U26.E5(VSS#E5) U26.E8(VSS#E8) U26.E12(VSS#E12) U26.G1(VSS#G1) U26.G3(VSS#G3) U26.G5(VSS#G5) U26.G8(VSS#G8) U26.G10(VSS#G10) U26.G12(VSS#G12) U26.J1(VSS#J1) U26.J3(VSS#J3) U26.J10(VSS#J10) U26.J12(VSS#J12) U26.K2(VSS#K2) U26.K4(VSS#K4) U26.K9(VSS#K9) U26.K11(VSS#K11) U26.N2(VSS#N2) U26.N4(VSS#N4) U26.N9(VSS#N9) U26.N11(VSS#N11) U26.P1(VSS#P1) U26.P3(VSS#P3) U26.P10(VSS#P10) U26.P12(VSS#P12) U26.T1(VSS#T1) U26.T3(VSS#T3) U26.T5(VSS#T5) U26.T8(VSS#T8) U26.T10(VSS#T10) U26.T12(VSS#T12) U26.V1(VSS#V1) U26.V5(VSS#V5) U26.V8(VSS#V8) U26.V12(VSS#V12) U26.W2(VSS#W2) U26.W4(VSS#W4) U26.W9(VSS#W9) U26.W11(VSS#W11) U26.Y1(VSS#Y1) U26.Y5(VSS#Y5) U26.Y8(VSS#Y8) U26.Y12(VSS#Y12) U27.5(REFGND1) U27.6(REFGND2) U27.21(FB_B2) U27.36(VBACKUP) U27.42(GPIO10) U27.51(GND#51) U27.52(NC) U27.57(GND#57) U28.A6(VSS#A6) U28.C4(VSSQ#C4) U28.E7(VSS#E7) U28.G5(VSS#G5) U28.H10(VSS#H10) U28.J5(VSS#J5) U28.K8(VSS#K8) U28.N2(VSSQ#N2) U28.N5(VSSQ#N5) U28.P4(VSSQ#P4) U28.P6(VSSQ#P6) U29.2(GND) U30.2(GND) U31.5(GND) U31.9(E\N\) U32.3(GND) U33.8(GND) U34.4(GND) U35.4(GND) U36.2(GND) U37.5(GND) U37.9(EP) U38.4(GND) U38.9(EPAD) U40.3(GND) U41.2(GND) U42.2(GND) U43.4(GND) U43.10(PGND) U43.15(VSEL) U44.7(GND) U45.3(GND) U46.4(GND) U47.10(GNDA) U47.17(GND#17) U47.48(GND#48) U47.55(GND#55) U47.58(GND#58) U47.64(W\A\K\E\) U47.66(XOSC0) U47.80(GND#80) U47.114(GND#114) U48.1(GND1) U48.5(GND2) U48.10(AGND) U48.11(GND3) U48.13(TEST) U48.15(GND4) U48.25(GND5) U48.35(GND6) U48.47(GND7) U48.51(GND8) U49.1(ANODE) U50.4(GND) U51.6(GND) U52.8(GND) U53.B1(GND) U54.10(GND1) U54.11(GND2) U55.8(GND) U56.2(GND) U57.B1(GND) U58.6(GND1) U58.14(GND2) U58.19(GND3) U63.2(GND) U63.5(EP) U65.2(GND) U65.5(EP) U78.49(GND) U79.4(GND) U81.4(GND) U82.C1(GND) U83.C1(GND) U84.C1(GND) U84.C3(A1) U85.C1(GND) U86.2(CASEGND) U87.4(GND) U88.15(AVSS_ADC) U88.20(DRVSS.1) U88.21(DRVSS.2) U88.26(AVSS_DAC) U88.42(DVSS) U88.43(SELECT) U88.49(TPAD) U89.3(AGND) U89.6(OSC) U89.9(PGND) U89.16(VCCX) U89.25(EP) U89.A1 U89.A2 U89.A3 U89.A4 U90.20(GND#20) U90.51(GND#51) U90.59(GND#59) U91.1(GND#1) U91.2(GND#2) U91.3(GND#3) U91.7(GND#7) U92.25(GND) U92.33(EP) U93.3(GND) U94.3(GND) U95.8(GND) U96.2(GND) U97.4(GND) U98.11(GND1) U98.12(GND2) U98.13(GND3) U98.25(EP) U99.4(GND) U100.25(GND) U100.33(EP) U101.11(GND1) U101.12(GND2) U101.13(GND3) U101.25(EP) U102.4(GND) U103.3(GND) U104.1(GND#1) U104.2(GND#2) U104.3(GND#3) U104.7(GND#7) U105.6(GND) U105.9(PAD) U106.4(GND) U107.3(GND) U108.4(GND) U109.3(A2) U109.5(GND) U109.6(B2) U110.1(1\O\E\) U110.10(GND1) U110.11(GND2) U110.16(2\O\E\) U111.10(GND1) U111.11(GND2) U112.4(GND) U113.5(VSS) U114.10(GND1) U114.11(GND2) U115.3(GND) U116.2(GND) U117.3(GND) U118.1(1\O\E\) U118.10(GND1) U118.11(GND2) U118.16(2\O\E\) U119.1(1\O\E\) U119.7(1A2) U119.9(2A2) U119.10(GND1) U119.11(GND2) U119.12(2B2) U119.14(1B2) U119.16(2\O\E\) U120.1(PGND) U120.5(FB) U120.6(AGND) U120.11(EP) U121.3(GND) U121.7(EP) U122.3(A2) U122.5(GND) U122.6(B2) U123.1(1\O\E\) U123.10(GND1) U123.11(GND2) U123.16(2\O\E\) Y1.2 Y1.4 Y4.2 Y4.4
VBUS_5V0_TYPEA: C96.1 C398.1 J7.1(VCC) R125.2 U30.4(OUT)
VBUS_TYPEC1: C118.1 C415.1 C417.1 J13.A4(VBUS1) J13.A9(VBUS2) J13.B4(VBUS3) J13.B9(VBUS4) R160.1 U90.13(VBUS1) U91.4(IN1) U91.5(IN2) U91.6(IN3)
VBUS_TYPEC2: C126.1 C423.1 C428.1 C449.1 C450.1 C455.1 J15.A4(VBUS1) J15.A9(VBUS2) J15.B4(VBUS3) J15.B9(VBUS4) Q11.4(D1) Q11.7(D2) R135.2 R203.1 R485.1 U90.3(VBUS2) U104.4(IN1) U104.5(IN2) U104.6(IN3)
VCC1V1: C90.2 C94.1 C97.1 C98.1 C390.1 L6.2 R131.4 TP39.1(TP)
VCC1V1_SW: L6.1 U27.55(SW_B4A) U27.56(SW_B4B)
VCC1V8_CLKBUF: C12.2 C14.2 C15.2 C16.2 FL1.2 R23.2 R33.2 U6.4(VDD) U7.6(VDD)
VCC1V8_SYS: C9.2 C21.1 C22.1 C26.2 C78.1 C80.2 C101.1 C173.2 C178.2 C191.1 C195.1 C199.1 C334.1 C340.1 C349.1 C358.1 C361.1 C384.1 C439.2 FL1.1 L3.2 R9.2 R40.1 R41.2 R46.2 R49.2 R111.1 R112.1 R113.1 R114.1 R115.1 R116.1 R117.1 R118.1 R120.2 R133.1 R241.2 R262.2 R264.1 R273.2 R274.2 R275.2 R276.2 R277.2 R295.2 R296.2 R297.2 R299.2 R300.2 R301.2 R302.2 R303.2 R304.2 R306.2 R372.1 R373.1 R411.2 R454.1 TP32.1(TP) U1.1(VCCA) U10.1(VCCA) U11.5(VCC) U12.B4(VCC) U12.D1(VCCQ#D1) U12.E4(VCCQ#E4) U27.10(PVIN_LDO3) U28.C6(VCCQ#C6) U28.M4(VCCQ#M4) U28.N4(VCCQ#N4) U28.P3(VCCQ#P3) U28.P5(VCCQ#P5) U32.5(VCC) U51.1(VCCA) U54.2(VCCB) U96.5(VCC)
VCC1V8_SYS_SW: L3.1 U27.34(SW_B5A)
VCC2V5_PG: R329.1 R360.1 U81.2(PG)
VCC3V3_EXP: C184.1 C189.2 C190.1 J3.1 J3.17 R287.1 R288.1 R289.1 R290.1 R291.1 R293.1 R294.1 U57.A1(VOUT)
VCC3V3_TA: C142.1 C408.1 C437.2 C442.2 C451.2 C453.2 C457.2 C460.2 C489.1 C492.1 C500.1 J23.1 J23.2 J23.3 L11.2 R165.1 R166.1 R205.2 R206.2 R207.2 R208.2 R209.2 R210.2 R211.2 R212.2 R213.2 R214.2 R215.2 R216.2 R217.2 R218.2 R219.2 R220.2 R480.2 R486.2 R490.2 R527.2 R530.2 R531.2 R543.1 R546.2 R547.2 R548.2 R559.1 R563.2 TP88.1(TP) U45.5(VCC) U87.8(VCCB) U97.8(VCCB) U98.1(VCCA) U99.8(VCCB) U100.27(VCCP) U100.31(VCC) U101.1(VCCA) U102.8(VCCB) U120.8(SLEEP) U120.10(VOS)
VCC3V3_XDS: C135.2 C137.2 C147.2 C150.1 C156.1 C164.1 C166.1 C167.1 C452.2 C454.2 C458.1 C461.1 C469.1 C479.2 C481.2 C482.2 C483.2 R202.2 R233.1 R234.1 R239.1 R470.2 R474.2 R477.1 R479.1 R488.1 R494.2 R502.1 R503.1 R506.2 R514.2 R518.2 R522.2 R525.2 TP79.1(TP) U44.14(VCC) U47.7(VDD#7) U47.8(VDDA) U47.16(VDD#16) U47.26(VDD#26) U47.28(VDD#28) U47.39(VDD#39) U47.47(VDD#47) U47.51(VDD#51) U47.52(VDD#52) U47.69(VDD#69) U47.79(VDD#79) U47.90(VDD#90) U47.101(VDD#101) U47.113(VDD#113) U47.122(VDD#122) U97.1(VCCA) U99.1(VCCA) U102.1(VCCA) U105.3(OUT1) U105.4(OUT2) U109.8(VCCB) U111.2(VCCB) U112.8(VCCB)
VCC5V0_EXP: C181.1 C185.2 C186.1 J3.2 J3.4 U53.A1(VOUT)
VCC_0V85: C82.1 R359.1 TP30.1(TP) U27.9(VOUT_LDO3)
VCC_1V8_AUD: C409.1 C411.1 R411.1 U88.36(DVDD.1)
VCC_1V8_FT4232: C157.2 C158.2 C476.2 C480.1 U48.12(VCORE#12) U48.37(VCORE#37) U48.49(VREGOUT) U48.64(VCORE#64)
VCC_3V3_AUD: C124.1 C125.1 C402.1 C406.1 C407.1 C418.1 C419.1 C424.1 C425.1 C434.1 R399.1 R402.1 R403.1 R427.2 R435.1 U86.4(VCC) U88.16(DRVDD.1) U88.17(DRVDD.2) U88.24(DRVDD.3) U88.25(AVDD_DAC) U88.44(IOVDD) U93.5(VCC)
VCC_3V3_FT4232: C152.2 C162.2 C163.2 C468.2 C475.2 C491.2 C493.2 C497.1 C499.2 C502.2 FL14.2 FL15.2 LD8.2(ANODE) R508.2 R509.2 R510.2 U48.20(VCCIO#20) U48.31(VCCIO#31) U48.42(VCCIO#42) U48.50(VREGIN) U48.56(VCCIO#56) U110.2(VCCB) U113.8(VCC) U118.2(VCCB) U119.2(VCCB) U121.1(OUT) U123.2(VCCB)
VCC_3V3_MAIN: C51.1 C76.1 C77.1 C83.1 C88.2 C91.1 C92.1 C107.2 C108.1 C109.2 C280.1 C329.1 C330.1 C344.1 C354.1 C360.1 C368.1 C372.1 C376.1 C380.1 C383.1 C386.1 C387.1 C403.1 C404.2 C405.2 FL13.1 R80.1 R138.2 R397.2 R401.2 R443.2 R574.1 TP46.1(TP) TP48.1(TP) U21.B2(VIN) U27.4(VCCA) U27.8(PVIN_LDO4) U27.12(PVIN_LDO12) U27.17(PVIN_B2) U27.26(PVIN_B1) U27.35(PVIN_B5) U27.45(PVIN_B3) U27.48(VIO_IN) U27.54(PVIN_B4) U31.10(VCC) U36.5(VCC) U37.1(VIN1) U37.2(VIN2) U37.4(VBIAS) U89.17(VOUT)
VCC_3V3_MAIN_PG: R361.1 R443.1 U36.3(B) U89.21(PG)
VCC_3V3_SYS: C1.2 C2.1 C3.2 C4.1 C5.2 C6.2 C7.1 C13.2 C17.2 C18.1 C20.2 C23.1 C25.2 C35.2 C37.1 C38.1 C39.1 C43.1 C61.1 C62.1 C65.1 C66.2 C71.1 C75.1 C87.2 C103.2 C106.2 C111.1 C112.2 C127.1 C133.1 C151.1 C169.1 C170.1 C172.2 C174.2 C176.2 C180.2 C182.1 C183.2 C187.1 C188.2 C194.1 C213.2 C219.1 C281.1 C297.1 C310.1 C311.1 C339.1 C371.1 C379.1 C388.1 C395.1 C396.1 C397.1 C400.1 C401.2 C422.1 C435.2 C438.1 C441.2 C443.1 C456.1 C459.2 C462.2 C463.2 C465.2 C466.2 C467.2 C471.2 C472.2 C473.2 C477.2 C478.2 C487.2 C488.2 C490.2 C496.2 C501.2 C503.2 C506.2 FB3.2 FL11.1 J1.30 J1.32 J1.34 J1.36 J2.2(3-3V#2) J2.4(3-3V#4) J2.72(3-3V#72) J2.74(3-3V#74) J4.48 J4.50 J8.1 J19.5 J20.22 R1.2 R2.2 R3.2 R6.2 R13.2 R16.1 R17.1 R22.2 R29.1 R30.1 R31.1 R32.1 R38.1 R39.1 R44.2 R62.2 R68.2 R79.2 R83.2 R84.2 R85.2 R86.2 R87.2 R94.2 R97.2 R126.2 R128.1 R136.2 R143.2 R150.2 R151.1 R162.2 R167.1 R168.2 R172.2 R175.2 R176.2 R179.2 R181.2 R182.2 R183.1 R222.2 R223.1 R224.1 R250.2 R252.2 R263.2 R272.1 R278.1 R279.1 R285.2 R292.1 R317.2 R330.1 R335.2 R339.1 R346.2 R347.2 R353.2 R354.2 R355.1 R366.2 R367.2 R388.1 R390.2 R391.1 R392.2 R408.1 R409.1 R410.1 R433.1 R434.1 R435.2 R438.2 R451.2 R465.2 R498.2 R501.2 R504.2 R505.1 R516.2 R528.2 R534.2 R537.2 R538.1 R539.1 R541.2 R542.2 R544.1 R552.1 R558.1 R561.2 R564.1 R565.2 R566.1 R570.1 R571.2 TP47.1(TP) U1.14(VCCB) U2.27(VCCP) U2.31(VCC) U3.7(VCCB) U4.19(VCCB) U5.14(VCC) U8.1(VCC) U9.4(VCC) U10.8(VCCB) U16.4(V+) U17.B1(VS) U20.1(VIN) U24.5(VCC) U25.B1(VS) U28.E6(VCC#E6) U28.F5(VCC#F5) U28.J10(VCC#J10) U28.K9(VCC#K9) U29.4(V+) U33.16(VCC) U37.7(VOUT1) U37.8(VOUT2) U38.8(VCC) U40.5(VCC) U41.5(VCC) U42.5(VCC) U51.11(VCCB) U52.16(VCC) U54.3(VCCA) U55.16(VCC) U57.A2(VIN) U58.24(VCCA) U78.19(VDDIO#19) U78.30(VDDIO#30) U78.41(VDDIO#41) U79.1(VCC) U81.6(VIN) U82.B1(VS) U82.B3(A0) U82.C3(A1) U83.B1(VS) U83.B3(A0) U84.B1(VS) U84.B3(A0) U85.B1(VS) U85.C3(A1) U87.1(VCCA) U92.27(VCCP) U92.31(VCC) U94.5(VCC) U95.16(VCC) U98.23(VCCB1) U98.24(VCCB2) U101.23(VCCB1) U101.24(VCCB2) U103.5(VCC) U106.1(VCCA) U106.8(VCCB) U107.5(VCC) U108.8(VCC) U109.1(VCCA) U110.3(VCCA) U111.3(VCCA) U112.1(VCCA) U114.2(VCCB) U114.3(VCCA) U116.5(VCC) U117.5(VCC) U118.3(VCCA) U119.3(VCCA) U122.1(VCCA) U122.8(VCCB) U123.3(VCCA)
VCC_3V3_SYS_EN: R398.2 R400.2 R401.1 R575.2 TP53.1(TP) U27.47(GPIO4) U37.3(ON)
VCC_5V0: C27.1 C28.1 C95.1 C102.1 C138.1 C139.1 C171.1 C175.1 C179.1 C204.1 C436.1 C444.1 C446.1 C447.1 J4.36 J4.38 Q10.4(D1) Q10.7(D2) R196.2 R200.1 R270.1 R281.2 R447.1 R468.1 TP73.1(TP) U30.3(IN) U43.7(VOUT) U50.2(IN) U50.3(EN2) U53.A2(VIN) U58.11(VCC5V)
VCC_5V0_EN: R201.2 R398.1 U43.14(EN)
VCC_5V0_FB: R195.1 R200.2 U43.5(FB)
VCC_5V0_HDMICONN: C202.1 J5.18 U58.13(5V_OUT)
VCC_5V0_PG: R196.1 R197.2 U116.3(B)
VCC_CORE: C64.2 C70.1 C72.1 C73.1 C74.1 C93.1 C99.1 C100.1 C301.1 C317.1 C318.1 C319.1 C391.1 L1.2 L2.2 L5.2 R101.4 R110.1 TP25.1(TP)
VCC_CSI_IO: C8.1 C10.2 C11.2 C168.1 J1.38 J1.40 R4.2 R20.2 R245.1 R246.1 R247.2 R248.2 R249.1 U3.3(VCCA) U4.2(VCCA)
VCC_LM5141: C413.1 D9.2(ANODE) U89.10(VCC)
VDD1_LPDDR4_1V8: C302.1 C309.1 C314.2 C322.1 C328.1 C345.1 C355.1 C363.1 C370.1 C374.1 C375.2 C378.1 FL12.2 U26.F1(VDD1#F1) U26.F12(VDD1#F12) U26.G4(VDD1#G4) U26.G9(VDD1#G9) U26.T4(VDD1#T4) U26.T9(VDD1#T9) U26.U1(VDD1#U1) U26.U12(VDD1#U12)
VDD_1V0: C29.1 C48.1 C49.1 C50.1 C58.1 C59.1 C60.1 C209.1 C230.1 C267.1 C296.1 C312.1 C313.1 J4.2 J4.4 TP17.1(TP) U63.1(OUT) U78.6(VDD1P0#6) U78.24(VDD1P0#24) U78.31(VDD1P0#31) U78.42(VDD1P0#42)
VDD_1V2: C192.1 C198.1 C249.1 FB1.2 FB2.2 TP13.1(TP) U65.1(OUT)
VDD_2V5: C24.1 C54.1 C55.1 C63.1 C67.1 C193.1 C242.1 C256.1 C293.1 C300.1 C326.1 C327.1 J4.47 J4.49 L9.2 R325.1 R358.1 R360.2 TP29.1(TP) U63.4(IN) U65.4(IN) U78.3(VDDA2P5#3) U78.9(VDDA2P5#9)
VDD_2V5_FB: C327.2 R357.1 R358.2 U81.3(FB)
VDD_CANUART: C47.1 C277.1 R95.2 U18.H9(VDD_CANUART)
VDD_CANUART_EN: R574.2 R575.1 U21.A2(EN)
VDD_CORE: C227.1 C234.1 C246.1 C248.1 C255.1 C260.1 C274.1 C508.1(INPUT) C508.3(OUTPUT) C509.1(INPUT) C509.3(OUTPUT) C510.1(INPUT) C510.3(OUTPUT) C511.1(INPUT) C511.3(OUTPUT) C512.1(INPUT) C512.3(OUTPUT) C513.1(INPUT) C513.3(OUTPUT) C514.1(INPUT) C514.3(OUTPUT) FL3.1 FL4.1 FL9.2 R101.1 U18.J9(VDD_CORE#J9) U18.J11(VDD_CORE#J11) U18.J13(VDD_CORE#J13) U18.J15(VDD_CORE#J15) U18.K14(VDD_CORE#K14) U18.L9(VDD_CORE#L9) U18.L11(VDD_CORE#L11) U18.L13(VDD_CORE#L13) U18.M12(VDD_CORE#M12) U18.N11(VDD_CORE#N11) U18.N13(VDD_CORE#N13) U18.P10(VDD_CORE#P10) U18.P14(VDD_CORE#P14) U18.R9(VDD_CORE#R9) U18.R15(VDD_CORE#R15) U18.T16(VDD_CORE#T16) U18.U15(VDD_CORE#U15) U27.22(FB_B1)
VDD_CORE_REG_SW1: L1.1 U27.27(SW_B1A) U27.28(SW_B1B)
VDD_CORE_REG_SW2: L2.1 U27.15(SW_B2A) U27.16(SW_B2B)
VDD_CORE_REG_SW3: L5.1 U27.43(SW_B3A) U27.44(SW_B3B)
VDD_LPDDR4: C294.1 C295.1 C298.1 C299.1 C303.1 C304.1 C305.1 C306.1 C308.2 C315.1 C316.2 C320.1 C321.1 C323.1 C324.1 C325.1 C331.1 C332.1 C333.1 C335.1 C336.1 C337.1 C338.2 C341.1 C342.1 C343.1 C347.1 C348.1 C351.1 C352.1 C353.1 C359.1 C362.1 C364.1 C365.1 C366.1 C367.1 C369.2 C373.1 C377.1 C517.1(INPUT) C517.3(OUTPUT) C518.1(INPUT) C518.3(OUTPUT) C519.1(INPUT) C519.3(OUTPUT) C520.1(INPUT) C520.3(OUTPUT) C521.1(INPUT) C521.3(OUTPUT) C524.1(INPUT) C524.3(OUTPUT) C525.1(INPUT) C525.3(OUTPUT) R119.1 R122.1 R131.1 R352.2 R369.2 R370.2 U18.A2(VDDS_DDR#A2) U18.AA1(VDDS_DDR#AA1) U18.AB2(VDDS_DDR#AB2) U18.B1(VDDS_DDR#B1) U18.J7(VDDS_DDR#J7) U18.K8(VDDS_DDR#K8) U18.L7(VDDS_DDR#L7) U18.L8(VDDS_DDR_C) U18.M8(VDDS_DDR#M8) U18.N7(VDDS_DDR#N7) U18.P8(VDDS_DDR#P8) U26.A4(VDD2#A4) U26.A9(VDD2#A9) U26.AA3(VDDQ#AA3) U26.AA5(VDDQ#AA5) U26.AA8(VDDQ#AA8) U26.AA10(VDDQ#AA10) U26.AB4(VDD2#AB4) U26.AB9(VDD2#AB9) U26.B3(VDDQ#B3) U26.B5(VDDQ#B5) U26.B8(VDDQ#B8) U26.B10(VDDQ#B10) U26.D1(VDDQ#D1) U26.D5(VDDQ#D5) U26.D8(VDDQ#D8) U26.D12(VDDQ#D12) U26.F3(VDDQ#F3) U26.F5(VDD2#F5) U26.F8(VDD2#F8) U26.F10(VDDQ#F10) U26.H1(VDD2#H1) U26.H5(VDD2#H5) U26.H8(VDD2#H8) U26.H12(VDD2#H12) U26.K1(VDD2#K1) U26.K3(VDD2#K3) U26.K10(VDD2#K10) U26.K12(VDD2#K12) U26.N1(VDD2#N1) U26.N3(VDD2#N3) U26.N10(VDD2#N10) U26.N12(VDD2#N12) U26.R1(VDD2#R1) U26.R5(VDD2#R5) U26.R8(VDD2#R8) U26.R12(VDD2#R12) U26.U3(VDDQ#U3) U26.U5(VDD2#U5) U26.U8(VDD2#U8) U26.U10(VDDQ#U10) U26.W1(VDDQ#W1) U26.W5(VDDQ#W5) U26.W8(VDDQ#W8) U26.W12(VDDQ#W12) U27.50(FB_B4)
VDD_MMC1: C40.1 FL5.1 U20.5(QOD) U20.6(VOUT)
VDD_MMC1_SD: C52.2 C53.2 FL5.2 J22.4(VDD)
VDDA1V8: C84.1 C389.2 R132.2 TP40.1(TP) U27.7(VOUT_LDO4)
VDDA_1V8: C30.1 C214.1 C215.1 C216.1 C228.1 C263.1 C266.1 C515.1(INPUT) C515.3(OUTPUT) C516.1(INPUT) C516.3(OUTPUT) FL7.1 FL8.1 FL10.1 R132.3 U18.G18(VDDA_TEMP1) U18.L10(VDDA_TEMP2) U18.P16(VDDA_TEMP0) U18.T10(VDDA_1P8_USB)
VDDA_1V8_FB1: C44.1 C46.1 C243.1 C245.1 C262.1 C265.1 C278.1 FL8.2 U18.J10(VDDA_MCU) U18.K10(VDDA_PLL4) U18.K13(VDDA_PLL3) U18.M13(VDDA_PLL2) U18.N9(VDDA_PLL0) U18.R11(VDDA_PLL1)
VDDA_1V8_FB2: C236.1 C254.1 FL7.2 U18.T12(VDDA_1P8_CSIRX0)
VDDA_1V8_FB_OSC: C56.1 C286.1 FL10.2 U18.J8(VDDS_OSC0)
VDDA_CORE_CSI: C251.1 C252.1 C259.1 C261.1 FL3.2 U18.T11(VDDA_CORE_CSIRX0)
VDDA_CORE_USB: C271.1 C272.1 C275.1 FL4.2 U18.T9(VDDA_CORE_USB)
VDDA_DDR_PLL0: C269.1 C289.1 C292.1 FL9.1 U18.M9(VDDA_DDR_PLL0)
VDDA_LM5141: C421.2 U89.1(DEMB) U89.2(VDDA) U89.5(DITH) U89.19(FB)
VDDA_SYS_MON: R80.2 R332.1 U18.H12(VMON_ER_VSYS)
VDDC_1V2: C153.1 C154.1 C464.2 U47.87(VDDC#87) U47.115(VDDC#115)
VDDIM: C356.1 C357.1 U28.C2(VDDIM)
VDDR_CORE: C68.1 C237.1 C250.1 C253.1 C268.1 C273.1 C526.1(INPUT) C526.3(OUTPUT) C527.1(INPUT) C527.3(OUTPUT) R356.3 R384.1 U18.J14(VDDR_CORE#J14) U18.K12(VDDR_CORE#K12) U18.M10(VDDR_CORE#M10) U18.M14(VDDR_CORE#M14) U18.P9(VDDR_CORE#P9) U18.P12(VDDR_CORE#P12)
VDDSHV_SDIO: C31.1 C57.2 C350.1 R61.1 R90.2 R91.2 R92.2 R98.2 R99.2 R100.2 TP34.1(TP) U22.10(VCC) U27.13(VOUT_LDO1)
VINT_PMIC_1V8: C382.1 TP101.1(TP) U27.2(VOUT_LDOVINT)
ADCIN1: R428.2 R429.1 U90.6(ADCIN1)
ADCIN2: R424.1 R425.2 U90.10(ADCIN2)
ADDR_IO_EXP: R452.2 U92.26(ADDR)
ADDR_IO_EXP1: R1.1 U2.26(ADDR)
AUD_RSTN: R450.2 U88.33(R\E\S\E\T\) U93.4(Y)
AUDIO_EXT_REFCLK1: R42.2 R55.1
AUDIO_MSTRCLK: R407.1 U88.37(MCLK)
AUTO_100M_1000M_CONFIG: J4.26 U2.22(P25)
BOOTMODE0: RA5.1 U101.14(B8)
BOOTMODE1: RA5.2 U101.15(B7)
BOOTMODE2: RA5.3 U101.16(B6)
BOOTMODE3: RA5.4 U101.17(B5)
BOOTMODE4: RA6.4 U101.18(B4)
BOOTMODE5: RA6.3 U101.19(B3)
BOOTMODE6: RA6.2 U101.20(B2)
BOOTMODE7: RA6.1 U101.21(B1)
BOOTMODE8: RA3.1 U98.14(B8)
BOOTMODE9: RA3.2 U98.15(B7)
BOOTMODE10: RA3.3 U98.16(B6)
BOOTMODE11: RA3.4 U98.17(B5)
BOOTMODE12: RA4.1 U98.18(B4)
BOOTMODE13: RA4.2 U98.19(B3)
BOOTMODE14: RA4.3 U98.20(B2)
BOOTMODE15: RA4.4 U98.21(B1)
BOOTMODE_I2C_EN: R473.2 R474.1 U99.5(EN)
BOOTMODE_I2C_SCL: R478.1 R549.1 R559.2 TP77.1(TP) U100.29(SCL)
BOOTMODE_I2C_SDA: R476.1 R543.2 R551.1 TP86.1(TP) U100.30(SDA)
BOOTMODEON: R221.2 U45.4(Y) U98.22(O\E\) U101.22(O\E\)
BT_EN_SOC: J2.54(W_DISABLE2#) R250.1 U92.3(P02)
BT_UART_WAKE_SOC_1V8: R25.2 U1.3(A2)
BT_UART_WAKE_SOC_3V3: R22.1 R24.2 U1.12(B2) U92.12(P13)
BT_UART_WAKE_SOC_R: J2.20(UART_WAKE#) R24.1 R25.1
BT_WLAN_EN: J2.56(W_DISABLE1#) R10.1 R11.2
BUF_BOOTMODE_I2C1_SCL: R503.2 U47.82(PL1) U97.2(SCLA)
BUF_BOOTMODE_I2C1_SDA: R502.2 U47.81(PL0) U97.3(SDAA)
BUF_BOOTMODE_I2C_SCL: R479.2 U47.49(PG0) U99.2(SCLA)
BUF_BOOTMODE_I2C_SDA: R477.2 U47.50(PG1) U99.3(SDAA)
BUF_TEST_GPIO1: U44.1(1A) U47.74(PM4)
BUF_TEST_GPIO2: U47.73(PM5) U102.2(A1)
BUF_TEST_GPIO3: U44.3(2A) U47.72(PM6)
BUF_TEST_GPIO4: U44.5(3A) U47.71(PM7)
BUF_TEST_PORZN: U44.9(4A) U47.77(PM1)
BUF_TEST_POWERDOWN: U44.13(6A) U47.78(PM0)
BUF_TEST_WARMRESETN: U44.11(5A) U47.76(PM2)
CAN_FD_WKUP_HDR_INH: J8.5 R75.1
CAN_FD_WKUP_SW_INH: R82.2 U35.7(1Y)
CAN_IO_3V3: C104.1 C282.1 C283.1 FL13.2 R65.1 R139.2 R140.2 R149.1 R523.1 R535.1 U18.H8(VDDSHV_CANUART) U35.8(VCC)
CAP_VDDS0: C241.1 U18.G13(CAP_VDDS0)
CAP_VDDS1: C222.1 U18.K16(CAP_VDDS1)
CAP_VDDS2: C235.1 U18.T14(CAP_VDDS2)
CAP_VDDS3: C220.1 U18.M16(CAP_VDDS3)
CAP_VDDS4: C285.1 U18.R8(CAP_VDDS4)
CAP_VDDS5: C231.1 U18.G15(CAP_VDDS5)
CAP_VDDS6: C223.1 U18.J16(CAP_VDDS6)
CAP_VDDS_CANUART: C287.1 U18.G8(CAP_VDDS_CANUART)
CAP_VDDS_MCU: C264.1 U18.G10(CAP_VDDS_MCU)
CLKOUT0: R27.2 R28.2 U7.1(CLKIN)
CLKOUT_OSC: R27.1 U6.3(OUTPUT)
COM_SDIO_CLK: J2.9(SDIO_CLK/SYSCLK) R243.1
COM_SDIO_CMD: J2.11(SDIO_CMD) R267.1
COM_SDIO_D0: J2.13(SDIO_DATA0) R269.1
COM_SDIO_D1: J2.15(SDIO_DATA1) R268.1
COM_SDIO_D2: J2.17(SDIO_DATA2) R266.1
COM_SDIO_D3: J2.19(SDIO_DATA3) R265.1
COMP_LM5141: C433.1 R441.1 U89.20(COMP)
CONN_MCU_PORZ: J8.28 R465.1 U96.1(A)
CONN_MCU_RESETZ: J8.25 Q3.1(G) R390.1
CPSW1_GPIO_0: J6.14 Q7.1(D1) Q7.2(D2) Q7.5(D3) Q7.6(D4) Q7.8(D5) R367.1
CPSW1_LED_1000: J6.12 Q5.1(D1) Q5.2(D2) Q5.5(D3) Q5.6(D4) Q5.8(D5)
CPSW1_LED_ACT: J6.13 Q6.1(D1) Q6.2(D2) Q6.5(D3) Q6.6(D4) Q6.8(D5) R366.1
CPSW_ETH1_D0N: J6.10(MX0-) U78.2(TD_M_A)
CPSW_ETH1_D0P: J6.9(MX0+) U78.1(TD_P_A)
CPSW_ETH1_D1M: J6.8(MX1-) U78.5(TD_M_B)
CPSW_ETH1_D1P: J6.7(MX1+) U78.4(TD_P_B)
CPSW_ETH1_D2M: J6.6(MX2-) U78.8(TD_M_C)
CPSW_ETH1_D2P: J6.5(MX2+) U78.7(TD_P_C)
CPSW_ETH1_D3M: J6.4(MX3-) U78.11(TD_M_D)
CPSW_ETH1_D3P: J6.3(MX3+) U78.10(TD_P_D)
CPSW_ETH1_GPIO_0: R83.1 R334.2 R342.1 R365.1 TP20.1(TP)
CPSW_ETH1_GPIO_1: R84.1 R333.2 R341.1 TP21.1(TP)
CPSW_ETH1_LED0: TP18.1(TP) U78.47(LED_0)
CPSW_ETH1_LED_1000: R86.1 R327.1 R336.2 TP23.1(TP) U78.46(LED_1)
CPSW_ETH1_LED_ACT: R85.1 R337.2 R364.1 TP22.1(TP) U78.45(LED_2)
CPSW_ETH2_INH: J4.28 R70.2
CPSW_ETH2_WAKE: J4.30 U18.E13(WKUP_I2C0_SDA)
CPSW_ETH_INTN: R53.1 R78.1
CPSW_RGMII1_ETH1_CLK: R26.2 U78.15(XI)
CPSW_RGMII1_ETH1_CLK_OUT: TP28.1(TP) U78.18(CLK_OUT)
CPSW_RGMII1_ETH1_RBIAS: C307.2 R351.1 U78.12(RBIAS)
CPSW_RGMII1_MDC: R108.2 R354.1 U78.16(MDC)
CPSW_RGMII1_MDIO: R107.2 R355.2 U78.17(MDIO)
CPSW_RGMII1_RD0: R96.2 R347.1 U18.AB16(RGMII1_RD0) U78.33(RX_D0)
CPSW_RGMII1_RD1: U18.V15(RGMII1_RD1) U78.34(RX_D1)
CPSW_RGMII1_RD2: R93.2 R346.1 U18.W15(RGMII1_RD2) U78.35(RX_D2)
CPSW_RGMII1_RD3: U18.V14(RGMII1_RD3) U78.36(RX_D3)
CPSW_RGMII1_RESETN: R440.1 U41.4(Y) U78.43(RESET_N)
CPSW_RGMII1_RX_CTL: R339.2 R340.2 U18.AA15(RGMII1_RX_CTL) U78.38(RX_DV/RX_CTRL)
CPSW_RGMII1_RXC: R348.1 U18.AA16(RGMII1_RXC)
CPSW_RGMII1_TD0: U18.Y17(RGMII1_TD0) U78.28(TX_D0)
CPSW_RGMII1_TD1: U18.V16(RGMII1_TD1) U78.27(TX_D1)
CPSW_RGMII1_TD2: U18.Y16(RGMII1_TD2) U78.26(TX_D2)
CPSW_RGMII1_TD3: U18.AA17(RGMII1_TD3) U78.25(TX_D3)
CPSW_RGMII1_TX_CTL: U18.W16(RGMII1_TX_CTL) U78.37(TX_EN/TX_CTRL)
CPSW_RGMII1_TXC: R322.2 U78.29(GTX_CLK)
CPSW_RGMII2_ETH2_CLK: J4.22 R37.2
CPSW_RGMII2_RD0: J4.27 U18.AA21(RGMII2_RD0)
CPSW_RGMII2_RD1: J4.35 U18.Y20(RGMII2_RD1)
CPSW_RGMII2_RD2: J4.33 U18.AB21(RGMII2_RD2)
CPSW_RGMII2_RD3: J4.29 U18.AB20(RGMII2_RD3)
CPSW_RGMII2_RX_CTL: J4.21 U18.W18(RGMII2_RX_CTL)
CPSW_RGMII2_RXC: J4.23 U18.AA20(RGMII2_RXC)
CPSW_RGMII2_TD0: J4.15 U18.AA19(RGMII2_TD0)
CPSW_RGMII2_TD1: J4.11 U18.Y18(RGMII2_TD1)
CPSW_RGMII2_TD2: J4.9 U18.AA18(RGMII2_TD2)
CPSW_RGMII2_TD3: J4.5 U18.W17(RGMII2_TD3)
CPSW_RGMII2_TX_CTL: J4.17 U18.Y19(RGMII2_TX_CTL)
CPSW_RGMII2_TXC: J4.3 R56.2
CPSW_RGMII2_TXC_R: R56.1 U18.AB19(RGMII2_TXC)
CPSW_RGMII_INTN: J4.10 R78.2 R335.1 U78.44(INT/PWDN)
CPSW_RGMII_TXC_R: R322.1 U18.AB17(RGMII1_TXC)
CS_LM5141: L10.2 R397.1 U89.18(CS)
CSI0_FLEX_RXCLKN: J20.8 U8.28(D0-B)
CSI0_FLEX_RXCLKP: J20.9 U8.29(D0+B)
CSI0_FLEX_RXN0: J20.2 U8.26(D1-B)
CSI0_FLEX_RXN1: J20.5 U8.24(D2-B)
CSI0_FLEX_RXN2: J20.11 U8.22(D3-B)
CSI0_FLEX_RXN3: J20.14 U8.20(CEC_B)
CSI0_FLEX_RXP0: J20.3 U8.27(D1+B)
CSI0_FLEX_RXP1: J20.6 U8.25(D2+B)
CSI0_FLEX_RXP2: J20.12 U8.23(D3+B)
CSI0_FLEX_RXP3: J20.15 U8.21(HPD_B)
CSI0_MIPI_RXCLKN: J1.7 U8.37(D0-A)
CSI0_MIPI_RXCLKP: J1.5 U8.38(D0+A)
CSI0_MIPI_RXN0: J1.11 U8.35(D1-A)
CSI0_MIPI_RXN1: J1.15 U8.33(D2-A)
CSI0_MIPI_RXN2: J1.19 U8.31(D3-A)
CSI0_MIPI_RXN3: J1.23 U8.18(CEC_A)
CSI0_MIPI_RXP0: J1.9 U8.36(D1+A)
CSI0_MIPI_RXP1: J1.13 U8.34(D2+A)
CSI0_MIPI_RXP2: J1.17 U8.32(D3+A)
CSI0_MIPI_RXP3: J1.21 U8.19(HPD_A)
CSI0_RXCLKN: U8.6(D0-) U18.AB14(CSI0_RXCLKN)
CSI0_RXCLKP: U8.5(D0+) U18.AB13(CSI0_RXCLKP)
CSI0_RXN0: U8.8(D1-) U18.W12(CSI0_RXN0)
CSI0_RXN1: U8.11(D2-) U18.Y13(CSI0_RXN1)
CSI0_RXN2: U8.13(D3-) U18.AA13(CSI0_RXN2)
CSI0_RXN3: U8.15(CEC) U18.AB11(CSI0_RXN3)
CSI0_RXP0: U8.7(D1+) U18.W13(CSI0_RXP0)
CSI0_RXP1: U8.10(D2+) U18.Y14(CSI0_RXP1)
CSI0_RXP2: U8.12(D3+) U18.AA12(CSI0_RXP2)
CSI0_RXP3: U8.14(HPD) U18.AB10(CSI0_RXP3)
