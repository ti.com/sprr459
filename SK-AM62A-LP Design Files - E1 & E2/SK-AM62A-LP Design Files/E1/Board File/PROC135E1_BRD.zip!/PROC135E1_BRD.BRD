# Allegro board PROC135E1_BRD.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MMC1_D0: length 55.6
  TOP w0.132: U18.B22 v1(31.48,112.46)
  TOP w0.14: U22.8 8.42,95.64 8.58,95.48 v1(8.58,95.43) 8.58,95.14 R100.1
  L05_SIG02 w0.102: v1(8.58,95.43) 8.58,94.77 8.3,94.49 7.37,94.49 7.21,94.66 7.21,94.87 7.33,94.99 7.96,94.99 8.18,95.21 8.18,95.77 8.49,96.08 8.49,98.67 8,99.15 8,103.24 8.44,103.67 8.44,105.94 10.29,107.8 10.29,110.04 13.87,113.62 13.87,113.81 13.39,114.3 13.39,114.49 13.52,114.62 13.71,114.62 14.2,114.13 14.39,114.13 14.52,114.27 14.52,114.46 14.03,114.95 14.03,115.14 14.17,115.27 14.36,115.27 14.84,114.78 15.03,114.78 15.57,115.32 17.81,115.32 18.03,115.54 26.4,115.54 27.34,114.6 27.34,113.57 28.47,112.44 29.84,112.44 30.28,112.88 30.87,112.88 31.08,112.68 31.27,112.68 v1(31.48,112.46)
  BOTTOM w0.14: J22.7 6.17,94.16 7.23,95.21 7.23,95.66 7.51,95.94 8.07,95.94 v1(8.58,95.43)
MMC1_D1: length 56
  TOP w0.132: U18.D21 v1(33.08,111.66)
  TOP w0.14: U22.7 7.92,95.58 7.78,95.44 ; R99.1 7.92,95.3 7.78,95.44 ; v1(7.77,95.44) 7.78,95.44
  L05_SIG02 w0.102: v1(7.77,95.44) 7.37,95.84 7.37,96.27 7.57,96.47 7.57,96.72 7.37,96.93 7.37,97.24 7.58,97.45 7.58,97.69 7.37,97.91 7.37,103.54 7.81,103.98 7.81,106.18 9.1,107.47 9.1,113.64 11.08,115.63 11.08,116.07 12.75,117.74 16.66,117.74 16.97,117.44 29.93,117.44 32.68,114.69 32.68,112.06 v1(33.08,111.66)
  BOTTOM w0.14: J22.8 6.42,93.06 7.77,94.4 v1(7.77,95.44)
MMC1_D2: length 55.8
  TOP w0.132: U18.C22 v1(32.28,112.46)
  TOP w0.14: R91.1 8.21,98.39 v1(8.08,98.26) 8.42,97.92 U22.2
  L05_SIG02 w0.102: v1(8.08,98.26) 7.67,98.67 7.67,103.37 8.12,103.82 8.12,106.06 9.4,107.34 9.4,111.02 11.13,112.75 11.13,113.08 14.21,116.16 14.5,116.16 14.63,116.28 14.63,117.05 14.75,117.17 14.93,117.17 15.06,117.05 15.06,116.28 15.18,116.16 15.36,116.16 15.49,116.28 15.49,117.05 15.62,117.17 15.79,117.17 15.92,117.05 15.92,116.28 16.05,116.16 17.72,116.16 18.06,116.5 27.16,116.5 27.36,116.3 27.36,115.27 27.54,115.09 27.74,115.09 27.93,115.29 27.93,116.75 28.15,116.97 28.68,116.97 29.58,116.07 29.78,116.07 30.08,116.37 30.31,116.37 30.5,116.18 30.5,115.94 30.23,115.68 30.23,115.42 30.61,115.04 30.61,113.64 31.24,113 31.74,113 v1(32.28,112.46)
  BOTTOM w0.14: v1(8.08,98.26) 8.08,98.73 6.05,100.76 J22.1
MMC1_D3: length 57.1
  TOP w0.132: U18.D22 v1(33.08,112.47)
  TOP w0.14: v1(6.52,99.13) 6.86,98.79 R92.1 7.14,98.57 7.92,97.79 U22.3
  L05_SIG02 w0.102: v1(33.08,112.47) 33.08,114.73 32.82,114.99 32.82,116.6 29.92,119.5 28.48,119.5 28.35,119.37 28.35,119.18 28.23,119.05 28.05,119.05 27.92,119.18 27.92,119.37 27.8,119.5 27.62,119.5 27.49,119.37 27.49,119.18 27.36,119.05 27.19,119.05 27.06,119.18 27.06,119.37 26.93,119.5 16.86,119.5 16.74,119.38 13.57,119.38 13.44,119.25 13.44,118.89 13.3,118.76 13.11,118.76 12.98,118.89 12.98,119.25 12.84,119.38 12.66,119.38 12.52,119.25 12.52,118.89 12.39,118.76 12.2,118.76 12.06,118.89 12.06,119.25 11.93,119.38 11.28,119.38 8.44,116.53 8.44,111.6 6.23,109.4 6.23,104.99 6.52,104.7 v1(6.52,99.13)
  BOTTOM w0.14: v1(6.52,99.13) 5.99,99.66 J22.2
MMC1_SD_EN: length 107
  TOP w0.14: R106.1 5.92,89.79 5.61,89.47 2.99,89.47 2.62,89.1 2.62,88.15 2.43,87.96 1.77,87.96 1.63,87.82 v1(1.63,87.52)
  L05_SIG02 w0.102: v1(17.14,39.24) 16.45,38.55 14.49,38.55 12.77,40.27 12.77,53.51 12.37,53.91 10.95,53.91 10.24,54.62 6.65,54.62 1.38,59.89 1.38,63.83 2.26,64.71 2.26,71.46 1.68,72.05 1.68,74.08 2.09,74.49 2.09,76.44 1.44,77.08 1.44,87.33 v1(1.63,87.52)
  L10_SIG03 w0.102: v1(17.14,39.24) 17.42,38.96 19.89,38.96 20.8,38.05 29.92,38.05 30.27,38.39 36.3,38.39 37.62,39.71 37.62,39.83 38.77,40.98 38.82,40.98 39.4,41.55 39.4,41.67 39.85,42.12 39.96,42.12 40.57,42.72 40.57,42.75 41.06,43.25 44.14,43.25 44.96,42.42 44.96,42.2 45.59,41.57 v1(49.86,41.57)
  BOTTOM w0.14: v1(49.86,41.57) 50.91,42.61 U92.4
MMC1_SD_LS_EN: length 21.9
  TOP w0.14: U24.4 6.49,92.37 v1(6.81,92.69) 6.82,92.7 R105.2 ; U20.3 R79.1 v1(10.55,103.41)
  L03_SIG01 w0.102: v1(10.55,103.41) 9.28,103.41 1.98,96.11 1.98,94.22 3.06,93.14 6.36,93.14 v1(6.81,92.69)
MMC1_SDCARD_EN: length 33.4
  TOP w0.14: v1(7.4,93.3) 7.71,93.3 7.85,93.16 R105.1
  L05_SIG02 w0.102: v1(5.81,76.79) 5.81,76.86 7.69,78.74 7.69,81.06 8.09,81.46 8.09,84.77 6.14,86.71 6.14,90.05 6.53,90.44 6.53,91.52 7.4,92.39 v1(7.4,93.3)
  BOTTOM w0.14: R374.1 17.74,75.87 16.7,76.91 13.76,76.91 12.65,78.02 11.49,78.02 10.27,76.79 v1(5.81,76.79)
MMC1_SDCD: length 32.5
  TOP w0.132: U18.E18 v1(33.88,109.26)
  TOP w0.14: R97.1 v1(22.9,94.96)
  L05_SIG02 w0.102: v1(33.88,109.26) 33.88,109.03 34.28,108.63 34.28,104.26 33.48,103.46 33.48,102.65 33.3,102.47 32.88,102.47 32.68,102.27 32.68,101.84 32.5,101.67 30.33,101.67 29.99,101.33 29.53,101.33 28.52,100.32 25.86,100.32 24.51,98.97 24.51,97.42 23.81,96.72 23.81,95.27 23.5,94.96 v1(22.9,94.96)
  BOTTOM w0.14: J22.9 16.06,95.03 U79.5 16.97,95.37 17.21,95.61 18.61,95.61 19.26,96.26 20.45,96.26 21.08,95.63 22.32,95.63 22.63,95.31 22.63,95.23 v1(22.9,94.96)
MMC2_CLK: length 63.2
  L05_SIG02 w0.102: v1(29.81,149.6) 29.81,141.54 28.62,140.35 28.62,139.21 26.35,136.95 23.16,136.95 20.04,133.83 20.04,133.21 18.28,131.45 18.28,127.06 20.98,124.36 20.98,123.3 21.52,122.76 26.62,122.76 27.08,123.22 29.71,123.22 v1(33.96,118.98)
  BOTTOM w0.14: R244.1 R243.2 R242.1 25.32,152.53 R241.1 28.9,152.53 29.81,151.62 v1(29.81,149.6) ; R316.2 35.61,116.35 35.13,116.83 34.65,116.83 33.96,117.52 v1(33.96,118.98)
MMC2_CMD: length 66.9
  TOP w0.132: U18.G22 v1(35.48,112.46)
  L05_SIG02 w0.102: v1(17.99,138.36) 17.99,138.87 18.18,139.05 19.86,139.05 19.96,139.15 19.96,141.17 20.09,141.31 20.5,141.31 20.64,141.44 20.64,141.63 20.5,141.76 20.09,141.76 19.96,141.9 19.96,142.15 19.86,142.25 19.58,142.25 19.44,142.11 19.44,140.31 19.31,140.17 19.12,140.17 18.98,140.31 18.98,142.13 18.85,142.25 18.67,142.25 18.53,142.11 18.53,139.61 18.39,139.47 18.2,139.47 18.07,139.61 18.07,142.13 17.94,142.25 17.68,142.25 17.55,142.13 17.55,137.16 16.97,136.58 16.97,134.67 17.11,134.53 17.81,134.53 17.94,134.4 17.94,134.21 17.81,134.07 17.11,134.07 16.97,133.94 16.97,133.06 15.73,131.81 15.73,127.42 16.5,126.64 17.8,126.64 20.35,124.09 20.35,122.98 21.2,122.13 29.64,122.13 34.21,117.56 34.21,116.1 35.07,115.24 35.07,113.17 35.48,112.77 v1(35.48,112.46)
  BOTTOM w0.14: R259.2 R267.2 R275.1 v1(17.99,138.36)
MMC2_D0: length 67.1
  TOP w0.132: U18.E20 v1(33.88,110.86)
  L05_SIG02 w0.102: v1(12.91,138.36) 13.34,138.79 13.34,141.24 13.17,141.41 12.7,141.41 12.57,141.28 12.57,139.84 12.44,139.71 12.25,139.71 12.11,139.84 12.11,141.28 11.98,141.41 11.79,141.41 11.66,141.28 11.66,139.84 11.52,139.71 11.33,139.71 11.2,139.84 11.2,141.28 11.07,141.41 10.5,141.41 10.32,141.24 10.32,139.43 10.48,139.27 12.01,139.27 12.25,139.03 12.25,137.61 12.48,137.39 12.64,137.39 13.02,137.77 13.19,137.77 13.31,137.65 13.31,137.48 12.93,137.1 12.93,136.94 13.05,136.82 13.22,136.82 13.59,137.19 13.76,137.19 13.88,137.07 13.88,136.9 13.51,136.53 13.51,136.36 13.97,135.9 13.97,132.79 12.88,131.71 12.88,127.37 13.87,126.38 15.24,126.38 15.99,125.63 17.52,125.63 19.3,123.85 19.3,122.61 20.17,121.74 20.17,120.83 20.95,120.05 24.89,120.05 25.36,120.52 29.71,120.52 33.19,117.03 33.19,115.1 33.48,114.81 33.48,111.26 v1(33.88,110.86)
  BOTTOM w0.14: v1(12.91,138.36) R277.1 R269.2 R261.2
MMC2_D1: length 67.2
  TOP w0.132: U18.F21 v1(34.68,111.66)
  L05_SIG02 w0.102: v1(34.68,111.66) 34.28,112.06 34.28,112.66 33.79,113.15 33.79,114.94 33.53,115.2 33.53,117.24 29.28,121.49 20.92,121.49 19.66,122.74 19.66,123.92 17.64,125.93 16.17,125.93 15.38,126.72 13.96,126.72 13.18,127.5 13.18,131.57 14.33,132.72 14.33,136.86 14.57,137.1 15.35,137.1 15.47,137.23 15.47,137.68 15.33,137.83 14.99,137.83 14.44,138.37 14.44,139.77 14.57,139.9 15.38,139.9 15.52,140.04 15.52,140.23 15.38,140.36 14.57,140.36 14.44,140.49 14.44,140.85 14.57,140.98 16.16,140.98 16.29,141.11 16.29,141.3 16.16,141.44 14.57,141.44 14.44,141.57 14.44,141.76 14.57,141.89 16.16,141.89 16.29,142.03 16.29,142.22 16.16,142.35 14.57,142.35 14.44,142.48 14.44,142.75 14.57,142.88 16.43,142.88 16.67,142.64 16.67,140.48 15.94,139.75 15.94,138.85 v1(15.45,138.36)
  BOTTOM w0.14: R260.2 R268.2 R276.1 v1(15.45,138.36)
MMC2_D2: length 67
  TOP w0.132: U18.F20 v1(34.68,110.86)
  L05_SIG02 w0.102: v1(34.68,110.86) 35.08,111.26 35.08,112.63 34.09,113.62 34.09,115.06 33.83,115.33 33.83,117.44 29.45,121.82 21.02,121.82 20.03,122.82 20.03,123.98 17.72,126.29 16.31,126.29 15.42,127.17 15.42,131.94 16.6,133.11 16.6,136.89 17.12,137.42 17.12,142.35 17.44,142.66 20.9,142.66 21.03,142.53 21.03,141.58 21.16,141.44 21.35,141.44 21.49,141.58 21.49,142.53 21.62,142.66 21.81,142.66 21.94,142.53 21.94,141.58 22.08,141.44 22.27,141.44 22.4,141.58 22.4,142.53 22.53,142.66 22.72,142.66 22.86,142.53 22.86,141.58 22.99,141.44 23.18,141.44 23.32,141.58 23.32,142.53 23.45,142.66 24.04,142.66 24.54,142.16 v1(24.54,138.36)
  BOTTOM w0.14: v1(24.54,138.36) R274.1 R266.2 R258.2
MMC2_D3: length 67
  TOP w0.132: U18.G21 v1(35.48,111.66)
  L05_SIG02 w0.102: v1(35.48,111.66) 35.48,111.83 35.89,112.24 35.89,114.85 34.51,116.23 34.51,117.8 29.89,122.43 21.38,122.43 20.67,123.13 20.67,124.2 17.96,126.92 17.96,132.15 18.81,132.99 18.81,133.81 19.21,134.21 19.21,134.38 18.93,134.66 18.93,134.82 19.05,134.94 19.22,134.94 19.5,134.66 19.67,134.66 19.79,134.78 19.79,134.95 19.51,135.23 19.51,135.4 19.63,135.52 19.8,135.52 20.07,135.24 20.24,135.24 20.88,135.88 20.88,136.77 20.57,137.08 18.19,137.08 18.09,137.19 18.09,137.45 18.2,137.55 21.4,137.55 21.52,137.67 21.52,137.92 21.38,138.06 18.7,138.06 18.55,138.21 18.55,138.5 18.71,138.67 22.46,138.67 22.61,138.81 22.61,140.2 22.71,140.3 23.01,140.3 23.13,140.19 23.13,137.76 23.35,137.54 24.75,137.54 25.58,138.36 v1(27.08,138.36)
  BOTTOM w0.14: R257.2 R265.2 R273.1 v1(27.08,138.36)
Net_1346: length 0.6
  TOP w0.132: 44.68,103.26 v1(45.08,102.87)
Net_1348: length 0.6
  TOP w0.132: 40.68,96.07 v1(41.08,95.67)
Net_1351: length 0.6
  TOP w0.132: 42.28,100.07 v1(42.68,99.67)
Net_1352: length 0.6
  TOP w0.132: 41.48,97.67 v1(41.88,97.26)
Net_1362: length 0.6
  TOP w0.132: 38.28,96.86 v1(37.88,96.47)
Net_1363: length 0.6
  TOP w0.132: 39.88,96.07 v1(40.28,95.67)
Net_1364: length 0.6
  TOP w0.132: 39.88,96.86 v1(40.28,96.47)
Net_1367: length 0.6
  TOP w0.132: 33.48,99.26 v1(33.08,98.87)
Net_1368: length 0.6
  TOP w0.132: 32.68,99.26 v1(32.28,98.87)
Net_1369: length 0.6
  TOP w0.132: 34.28,100.07 v1(33.88,99.67)
OSC0: length 5
  TOP w0.14: Y4.3 59.06,27.8 58.92,27.66 58.92,26.07 59.43,25.55 C146.2 59.17,25.25 U47.88
OSC1: length 3.3
  TOP w0.14: Y4.1 58.24,26.21 58.38,26.07 C145.2 58.77,25.17 U47.89
OSPI0_CSN0: length 2
  TOP w0.132: U18.H21 v1(36.28,111.66)
  BOTTOM w0.14: R320.2 v1(36.28,111.66)
OSPI0_LBCLK: length 25.2
  L05_SIG02 w0.102: v1(51.31,118.87) 50.38,117.94 42.71,117.94 42.51,117.73 42.51,116.93 42.26,116.68 41.51,116.68 41.39,116.56 41.39,115.24 41.26,115.11 41.07,115.11 40.95,115.23 40.95,117.18 40.81,117.32 40.6,117.32 40.48,117.2 40.48,115.26 40.35,115.14 40.1,115.14 39.96,115.27 v1(39.96,117.11)
  BOTTOM w0.14: v1(39.96,117.11) 39.96,115.51 R319.1 ; R312.2 v1(51.31,118.87)
OSPI0_LBCLKO_R: length 1.3
  TOP w0.132: U18.K22 v1(37.88,112.46)
  BOTTOM w0.14: v1(37.88,112.46) 37.88,112.47 37.88,112.87 R319.2
OSPI_CLK: length 27.8
  TOP w0.132: U18.L22 v1(38.68,112.46)
  L05_SIG02 w0.102: v1(48.42,119.04) 49.02,119.04 49.26,119.28 49.26,119.45 49.18,119.53 49.18,119.7 49.3,119.82 49.46,119.82 49.55,119.73 49.72,119.73 49.97,119.99 50.12,119.99 50.29,119.82 50.29,119.67 49.24,118.62 47.99,118.62 47.87,118.74 47.87,118.88 47.75,119 47.58,119 47.46,118.89 47.46,118.74 47.35,118.62 46.34,118.62 46.22,118.74 46.22,119.08 46.1,119.2 45.93,119.2 45.81,119.08 45.81,118.74 45.69,118.62 45.53,118.62 45.41,118.74 45.41,119.08 45.29,119.2 45.12,119.2 45,119.08 45,118.74 44.88,118.62 44.71,118.62 44.59,118.74 44.59,119.08 44.47,119.2 44.31,119.2 44.19,119.08 44.19,118.74 44.07,118.62 43.3,118.62 43.13,118.79 43.13,119.06 42.98,119.21 41.45,119.21 41.06,118.83 41.06,118.66 41.19,118.53 41.19,118.36 41.07,118.24 40.91,118.24 40.78,118.37 40.61,118.37 40.26,118.02 38.51,118.02 38.14,117.65 38.14,116.27 38.6,115.81 38.6,112.55 v1(38.68,112.46)
  BOTTOM w0.14: R313.1 R311.1 v1(48.42,119.04)
OSPI_CS: length 27.7
  TOP w0.14: U12.C2 v1(50.35,122.4)
  L05_SIG02 w0.102: v1(50.35,122.4) 50.81,122.4 50.89,122.31 50.89,121.88 50.79,121.78 50.3,121.78 50.2,121.68 50.2,121.47 50.28,121.38 51.53,121.38 51.65,121.26 51.65,121.08 51.54,120.97 49.39,120.97 48.84,120.43 48.84,119.63 48.72,119.51 48.46,119.51 48.35,119.62 48.35,120.38 48.23,120.49 47.98,120.49 47.85,120.36 47.85,120 47.72,119.88 47.1,119.88 46.79,119.57 41.38,119.57 40.14,118.33 38.11,118.33 37.92,118.15 v1(36.86,118.15)
  BOTTOM w0.14: R320.1 36.28,115.4 36.86,115.97 v1(36.86,118.15) ; R304.1 50.69,122.06 v1(50.35,122.4)
OSPI_DQ0: length 22.8
  TOP w0.14: v1(36.4,119.93) 35.86,119.39 RA1.2 ; U12.D3 v1(49.35,123.4)
  L05_SIG02 w0.102: v1(36.4,119.93) 36.4,121.28 40.02,124.89 40.72,124.89 40.85,125.03 40.85,125.2 40.98,125.34 41.17,125.34 41.31,125.2 41.31,125.03 41.44,124.89 41.94,124.89 42.08,125.03 42.39,125.03 42.53,124.89 43.15,124.89 43.27,124.78 43.27,124.54 43.39,124.42 43.56,124.42 43.68,124.54 43.68,124.78 43.8,124.89 43.96,124.89 44.08,124.78 44.08,124.54 44.2,124.42 44.37,124.42 44.49,124.54 44.49,124.78 44.61,124.89 46.57,124.89 46.86,124.61 46.86,124.16 47.18,123.83 47.18,122.96 47.45,122.7 48.28,122.7 48.97,123.39 49.34,123.39 v1(49.35,123.4)
  BOTTOM w0.14: v1(49.35,123.4) 48.98,123.77 R299.1
OSPI_DQ1: length 19
  TOP w0.14: U12.D2 v1(50.35,123.4) ; v1(38.82,119.01) 38.68,118.87 RA2.1
  L05_SIG02 w0.102: v1(50.35,123.4) 50.35,123.39 49.63,122.66 49.63,122.09 48.69,121.16 46.44,121.16 46.01,120.73 44.67,120.73 44.55,120.61 44.55,120.4 44.43,120.28 44.26,120.28 44.14,120.4 44.14,120.61 44.03,120.73 43.86,120.73 43.74,120.61 43.74,120.4 43.62,120.28 43.45,120.28 43.33,120.4 43.33,120.61 43.21,120.73 43.04,120.73 42.93,120.61 42.93,120.4 42.81,120.28 42.64,120.28 42.52,120.4 42.52,120.61 42.4,120.73 42.23,120.73 42.11,120.61 42.11,120.4 41.99,120.28 41.83,120.28 41.71,120.4 41.71,120.61 41.59,120.73 41.42,120.73 41.3,120.61 41.3,120.4 41.18,120.28 41.01,120.28 40.89,120.4 40.89,120.61 40.77,120.73 39.79,120.73 39.35,120.29 39.35,119.82 38.82,119.29 v1(38.82,119.01)
  BOTTOM w0.14: R302.1 50.57,123.18 v1(50.35,123.4)
OSPI_DQ2: length 20.8
  TOP w0.14: U12.C4 v1(48.25,121.55) ; RA2.2 38.28,119.39 v1(38.82,119.93)
  L05_SIG02 w0.102: v1(48.25,121.55) 47.7,121.55 47.47,121.79 45.9,121.79 45.79,121.67 45.79,121.27 45.67,121.15 45.5,121.15 45.38,121.27 45.38,121.67 45.26,121.79 45.09,121.79 44.97,121.67 44.97,121.27 44.85,121.15 44.68,121.15 44.57,121.27 44.57,121.67 44.45,121.79 44.28,121.79 44.16,121.67 44.16,121.27 44.04,121.15 43.87,121.15 43.75,121.27 43.75,121.67 43.63,121.79 43.47,121.79 43.35,121.67 43.35,121.27 43.23,121.15 43.06,121.15 42.94,121.27 42.94,121.67 42.82,121.79 42.65,121.79 42.53,121.67 42.53,121.27 42.41,121.15 42.25,121.15 42.13,121.27 42.13,121.67 42.01,121.79 41.84,121.79 41.72,121.67 41.72,121.27 41.6,121.15 41.43,121.15 41.31,121.27 41.31,121.67 41.2,121.79 41.03,121.79 40.91,121.67 40.91,121.27 40.79,121.15 40.62,121.15 40.5,121.27 40.5,121.67 40.38,121.79 39.85,121.79 38.82,120.76 v1(38.82,119.93)
  BOTTOM w0.14: R303.1 47.91,121.89 v1(48.25,121.55)
OSPI_DQ3: length 20.3
  TOP w0.14: v1(34.92,119.93) 35.46,119.39 RA1.3 ; U12.D4 v1(48.35,123.4)
  L05_SIG02 w0.102: v1(34.92,119.93) 34.92,120.23 40.34,125.66 46.69,125.66 48.35,123.99 v1(48.35,123.4)
  BOTTOM w0.14: R300.1 v1(48.35,123.4)
OSPI_DQ4: length 23.1
  TOP w0.14: U12.D5 v1(46.35,123.4) ; v1(37.34,119.01) 37.48,118.87 RA2.4
  L05_SIG02 w0.102: v1(46.35,123.4) 46.1,123.14 46.1,122.87 45.96,122.73 45.67,122.73 45.57,122.84 45.57,123.2 45.37,123.4 41.39,123.4 41.27,123.28 41.27,123.11 41.39,122.99 43.32,122.99 43.43,122.88 43.43,122.71 43.3,122.58 40.98,122.58 40.86,122.7 40.86,123.28 40.74,123.4 40.45,123.4 39.54,122.49 39.37,122.49 39.07,122.79 38.91,122.79 38.79,122.67 38.79,122.5 39.09,122.2 39.09,122.04 38.97,121.92 38.8,121.92 38.5,122.22 38.33,122.22 38.21,122.1 38.21,121.93 38.51,121.63 38.51,121.46 38.39,121.34 38.22,121.34 37.92,121.64 37.76,121.64 37.64,121.52 37.64,121.35 37.94,121.05 37.94,120.89 37.77,120.72 37.77,119.44 v1(37.34,119.01)
  BOTTOM w0.14: R301.1 v1(46.35,123.4)
OSPI_DQ5: length 21.2
  TOP w0.14: U12.E3 v1(49.35,124.4) ; v1(34.92,119.01) 35.06,118.87 RA1.4
  L05_SIG02 w0.102: v1(49.35,124.4) 48.8,124.4 47.23,125.97 40.21,125.97 34.53,120.29 34.53,119.41 v1(34.92,119.01)
  BOTTOM w0.14: R297.1 v1(49.35,124.4)
OSPI_DQ6: length 22.1
  TOP w0.14: v1(37.34,119.93) 37.88,119.39 RA2.3 ; U12.E2 v1(50.35,124.4)
  L05_SIG02 w0.102: v1(50.35,124.4) 50.82,123.93 50.82,123.25 50.51,122.95 50.37,122.95 49.97,122.55 49.97,121.98 48.84,120.85 47.18,120.85 46.84,120.5 46.84,120.21 46.54,119.91 41.01,119.91 40.54,119.44 39.62,119.44 39.36,119.18 39.36,118.94 39.05,118.63 37.16,118.63 36.95,118.84 36.95,119.3 37.34,119.68 v1(37.34,119.93)
  BOTTOM w0.14: R296.1 v1(50.35,124.4)
OSPI_DQ7: length 23.7
  TOP w0.14: v1(36.4,119.01) 36.26,118.87 RA1.1 ; U12.E1 v1(51.35,124.4)
  L05_SIG02 w0.102: v1(51.35,124.4) 50.84,124.91 50.15,124.91 49.81,124.58 49.81,123.31 49.34,122.83 49.04,122.83 48.53,122.31 47.24,122.31 46.79,122.76 46.79,123.55 46.44,123.9 40.87,123.9 40.75,124.01 40.75,124.24 40.63,124.36 40.47,124.36 40.35,124.24 40.35,124.01 40.23,123.9 39.47,123.9 36.83,121.26 36.83,119.74 36.4,119.3 v1(36.4,119.01)
  BOTTOM w0.14: R295.1 v1(51.35,124.4)
OSPI_DQS: length 4
  TOP w0.14: U12.C3 v1(49.23,122.27)
  BOTTOM w0.14: v1(49.23,122.27) 48.93,121.97 R306.1 R305.1 50.43,121.66 51.31,120.78 R309.1
OSPI_DQS_SOC: length 25.2
  TOP w0.132: U18.L21 v1(38.68,111.66)
  L05_SIG02 w0.102: v1(38.68,111.66) 39,111.66 39.37,112.03 39.37,112.8 39.25,112.92 39.25,116.63 39.04,116.84 38.61,116.84 38.44,117 38.44,117.52 38.61,117.69 41.85,117.69 42.13,117.97 42.13,118.75 42.23,118.86 42.46,118.86 42.58,118.74 42.58,118.39 42.68,118.29 49.59,118.29 50.87,119.58 50.87,120.42 50.99,120.54 51.35,120.54 51.46,120.43 51.46,120.1 51.63,119.93 v1(51.97,119.93)
  BOTTOM w0.14: R312.1 51.7,120.21 v1(51.97,119.93)
OSPI_INTN: length 15.9
  TOP w0.132: U18.K20 v1(37.88,110.86)
  TOP w0.14: R50.1 R49.1 40.01,120.11 v1(39.81,119.91)
  BOTTOM w0.114: 37.48,111.32 37.48,112.3
  BOTTOM w0.14: v1(37.88,110.86) 37.88,110.93 37.48,111.32 ; v1(39.81,119.91) 39.31,119.41 39.31,118.77 38.31,117.76 38.31,115.54 37.6,114.82 37.6,113.22 37.37,112.99 37.37,112.41 37.48,112.3
OSPI_RSTN: length 7.7
  TOP w0.14: U12.A4 v1(47.35,119.4) ; v1(44.17,122.77) 44.17,122.84 44.27,122.95 R46.1 U11.4
  L10_SIG03 w0.102: v1(44.17,122.77) 45.51,121.43 46.1,121.43 46.87,120.66 46.87,119.88 v1(47.35,119.4)
P2_PP_EXT_ENABLE: length 2.6
  BOTTOM w0.14: U90.49 20.58,41.04 19.69,40.15 R449.1
PD_GPIO0: length 2
  BOTTOM w0.14: U90.16 18.18,49.3 17.53,49.95 R416.2
PD_GPIO2: length 4.3
  TOP w0.14: v1(19.3,51.78) 18.92,51.4 TP58.1
  BOTTOM w0.14: U90.18 18.98,49.26 19.3,49.58 v1(19.3,51.78)
PD_HRESET: length 1.8
  BOTTOM w0.14: R445.1 22.72,40.49 22.72,41.09 22.58,41.23 U90.44
PD_I2C_IRQ: length 55.9
  TOP w0.14: v1(49.96,46.29) 51.72,46.29 52.35,45.66 57.18,45.66 58.24,44.59 v1(58.24,40.04) ; R169.1 R167.2 24.39,47.52 24.01,47.91 v1(24.01,48.71)
  L10_SIG03 w0.102: v1(49.96,46.29) 49.95,46.3 49.47,46.3 49.18,46.01 48.88,46.01 48.57,46.33 47.58,46.33 47.36,46.11 39.35,46.11 38.72,46.74 38.41,46.74 37.92,47.22 37.32,47.22 37.18,47.09 37,47.09 33.09,47.09 32.66,46.65 32.66,44.93 31.2,43.47 30.68,43.47 30.22,43.02 29.95,43.02 29.57,42.64 26.75,42.64 25.65,41.54 24.99,41.54 23.74,42.79 23.74,48.44 v1(24.01,48.71)
  BOTTOM w0.14: U92.23 57.95,41.61 58.51,41.05 58.51,40.31 v1(58.24,40.04)
PD_M_I2C3_IRQ: length 1.9
  BOTTOM w0.14: U90.23 R412.2
PD_M_I2C3_SCL: length 53.1
  TOP w0.14: R161.2 v1(20.18,49.49)
  L10_SIG03 w0.102: v1(20.18,49.49) 20.82,48.85 23.08,48.85 23.55,49.32 24.62,49.32 25.22,49.92 31.05,49.92 31.54,50.41 41.89,50.41 42.27,50.79 45.04,50.79 45.65,51.4 48.36,51.4 49.1,52.13 50.62,52.13 53.57,55.08 53.57,56.48 55.6,58.51 60,58.51 60.89,59.4 64.16,59.4 v1(65.08,58.48)
  BOTTOM w0.14: v1(65.08,58.48) 65.37,58.77 R395.1 ; v1(20.18,49.49) U90.21
PD_M_I2C3_SDA: length 55.1
  TOP w0.14: R158.2 v1(20.18,50.4)
  L10_SIG03 w0.102: v1(20.18,50.4) 19.68,49.9 19.68,49.21 20.3,48.59 23.35,48.59 23.85,49.09 24.71,49.09 25.31,49.69 31.15,49.69 31.64,50.18 42.09,50.18 42.39,49.87 44.94,49.87 46.03,50.97 52.5,50.97 53.95,52.41 53.95,56.48 55.72,58.24 60.16,58.24 60.89,58.97 v1(61.22,58.97)
  BOTTOM w0.14: v1(61.22,58.97) 61.45,59.2 62.78,59.2 R396.1 ; v1(20.18,50.4) 20.66,49.92 20.66,49.16 20.58,49.08 U90.22
PD_MS_I2C1_IRQ: length 1.5
  BOTTOM w0.14: U90.29 24.5,47.76 24.64,47.89 R419.2
PD_MS_I2C1_SCL: length 50.3
  L10_SIG03 w0.102: v1(23.29,49.7) 23.43,49.7 24.11,50.37 24.91,50.37 25.48,50.94 40.82,50.94 42.6,52.72 48.87,52.72 49.58,53.43 51.16,53.43 52.94,55.21 52.94,56.55 55.36,58.97 59.49,58.97 61.04,60.52 63.91,60.52 v1(65.08,59.35)
  BOTTOM w0.14: v1(65.08,59.35) 65.27,59.54 R393.1 ; U90.27 22.58,48.99 v1(23.29,49.7) R415.2
PD_MS_I2C1_SDA: length 46.6
  L10_SIG03 w0.102: v1(61.22,59.88) 60.89,59.88 59.74,58.74 55.45,58.74 53.19,56.48 53.19,55.08 51.23,53.13 49.63,53.13 48.26,51.75 42.42,51.75 41.3,50.64 31.44,50.64 30.95,50.15 24.65,50.15 v1(24.21,49.7)
  BOTTOM w0.14: R394.1 62.27,59.54 61.93,59.88 v1(61.22,59.88) ; R414.2 v1(24.21,49.7) 23.69,49.18 23.41,49.18 22.98,48.76 U90.28
PD_S_I2C2_IRQ: length 2.6
  TOP w0.14: v1(25.33,45.76) 25.33,46 25.19,46.14 R169.2
  BOTTOM w0.14: U90.34 24.36,45.76 24.48,45.88 25.21,45.88 v1(25.33,45.76)
PD_S_I2C2_SCL: length 1.7
  BOTTOM w0.14: R421.2 24.79,47.13 24.22,46.56 U90.32
PD_S_I2C2_SDA: length 1.6
  BOTTOM w0.14: U90.33 24.25,46.16 24.46,46.37 R422.2
PD_SPI_CLK: length 50.9
  TOP w0.14: U34.6 59.16,62.49 59.46,62.19 59.46,58.97 58.68,58.18 J11.7
  L10_SIG03 w0.102: v1(26.37,43.85) 25.76,44.46 25.76,46.06 26.52,46.83 28.71,46.83 30.19,48.31 30.62,48.31 32,49.7 41.29,49.7 42.31,48.68 42.31,48.22 42.59,47.94 45.11,47.94 47.68,50.51 54.97,50.51 57.51,53.05 57.51,55.96 J11.7
  BOTTOM w0.14: v1(26.37,43.85) 26.15,43.64 R436.2
PD_SPI_MISO: length 51.6
  TOP w0.14: J11.5 61.22,58.05 61.72,58.56 61.72,60.54 62.41,61.22 U34.2 R146.2
  L10_SIG03 w0.102: J11.5 60.03,55.94 60.03,53.54 56.49,50 50.52,50 47.09,46.57 41.28,46.57 40.78,47.07 40.78,47.98 40.41,48.35 32.01,48.35 31.29,47.63 31.29,46.87 29.8,45.38 26.49,45.38 v1(26.37,45.51)
  BOTTOM w0.14: R426.2 26.13,45.51 v1(26.37,45.51)
PD_SPI_MOSI: length 53.3
  TOP w0.14: J11.8 59.95,55.85 59.95,63.18 59.37,63.76 U34.5
  L10_SIG03 w0.102: v1(26.37,44.69) 25.99,45.07 25.99,45.8 26.68,46.49 30.12,46.49 30.87,47.24 30.87,47.7 32.38,49.21 40.52,49.21 41.05,48.68 41.05,47.25 41.49,46.8 45.93,46.8 47.6,48.48 48.49,48.48 50.29,50.28 55.63,50.28 58.12,52.77 58.12,54.02 J11.8
  BOTTOM w0.14: v1(26.37,44.69) 26.07,44.4 R431.2
PD_SPI_SS: length 62.8
  TOP w0.14: R147.2 U34.1 62.48,59.95 62.05,59.53 62.05,58.48 62.51,58.03 62.51,53.99 61.93,53.4 57.89,53.4 57.36,53.94 57.36,56.66 56.89,57.12 J11.9
  L10_SIG03 w0.102: J11.9 54.94,55.93 54.94,52.9 52.78,50.74 46.81,50.74 44.99,48.91 42.57,48.91 41.56,49.92 31.9,49.92 30.59,48.61 30.08,48.61 28.68,47.21 25.86,47.21 24.03,45.38 24.03,43.22 v1(25.23,42.02)
  BOTTOM w0.14: v1(25.23,42.02) 25.01,42.24 R439.2
PD_VIN_3V3: length 1.8
  TOP w0.381: C123.2 15.81,44.58 16.04,44.35 v1(16.11,44.35)
  BOTTOM w0.14: v1(16.11,44.35) 16.3,44.16 U90.5
PMIC_AMUXOUT: length 2
  TOP w0.14: U27.1 21.5,76.54 22.29,75.75 TP36.1
PMIC_ENABLE: length 26.6
  TOP w0.14: TP42.1 11.86,66.32 v1(11.86,66.31) 11.01,65.46 7.16,65.46 5.32,67.3 4.78,67.3 3.66,68.42 U31.4 ; U36.1 v1(17.93,56.75)
  L05_SIG02 w0.102: v1(11.86,66.31) 11.86,61.08 16.19,56.75 v1(17.93,56.75)
PMIC_ENABLE_SEL: length 7.4
  TOP w0.14: J9.1 2.54,64.23 2.19,64.58 2.19,67.45 2.03,67.61 1.55,67.61 ; U31.1 2.16,68.22 1.55,67.61 ; 1.55,67.61 R138.1
PMIC_INT_B: length 8.8
  TOP w0.14: R127.2 27.3,81.75 27.13,81.92 27.13,81.93 27.14,81.94 27.14,82.65 27,82.79 R126.1 26.34,83.16 R123.2 TP33.1 24.85,84.08 22.55,84.08 21.52,83.04 U27.14
PMIC_INTN: length 46
  TOP w0.132: U18.F17 v1(34.68,108.46)
  TOP w0.14: v1(34.41,115.29) 33.96,115.73 R53.2 ; v1(28.03,80.48) 27.74,80.77 R127.1
  L10_SIG03 w0.102: v1(28.03,80.48) 28.03,81.63 28.13,81.73 28.13,82.52 27.2,83.45 27.2,94.8 30.06,97.67 32.45,97.67 32.68,97.9 32.68,98.23 32.91,98.47 33.25,98.47 34.28,99.5 34.28,99.83 34.51,100.07 34.78,100.07 34.85,100.07 35.08,100.3 U18.F17 v1(34.68,108.46) 35.08,108.86 35.65,108.86 35.88,109.1 35.88,110.23 35.89,110.24 36.11,110.47 36.45,110.47 36.68,110.7 36.68,111.83 36.3,112.21 36.3,113.4 v1(34.41,115.29)
PMIC_LPM_EN0: length 83.2
  TOP w0.132: U18.D12 v1(33.08,104.46)
  TOP w0.14: U31.8 3.16,75.29 3.61,75.74 4.69,75.74 v1(4.93,75.99) ; U31.3 3.16,68.35 3.91,67.6 v1(3.91,66.71) 5.23,66.71 6.37,65.58 R140.1 12.59,65.11 13.73,66.26 16.75,66.26 v1(17.72,67.23) 18.01,67.52 TP41.1
  L05_SIG02 w0.102: v1(3.91,66.71) 3.91,70.65 4.04,70.78 4.04,75.09 v1(4.93,75.99)
  L10_SIG03 w0.102: v1(17.72,67.23) 17.72,67.93 18.56,68.76 18.56,72.52 18.95,72.92 18.95,82.53 19.24,82.82 19.24,84.76 18.49,85.51 18.49,87.08 18.51,87.1 18.51,87.61 18.49,87.62 18.49,87.85 18.51,87.86 18.51,88.05 18.51,88.37 18.49,88.39 18.49,95.17 18.76,95.44 18.76,99.32 19.04,99.6 19.6,99.6 20.27,100.27 21.92,100.27 22.32,100.67 22.9,100.67 24.13,101.91 25.45,101.91 26.1,102.55 26.99,102.55 27.84,103.4 28.71,103.4 28.93,103.18 30.75,103.18 31.05,103.48 32.64,103.48 33.09,103.93 33.08,103.93 v1(33.08,104.46)
PMIC_NPWRON/ENABLE: length 33.5
  TOP w0.132: v1(17.74,83.17) U27.20
  TOP w0.14: R148.2 21.67,58.9 v1(20.41,60.16)
  L03_SIG01 w0.102: v1(17.74,83.17) 17.44,83.17 17.01,82.74 17.01,79.13 16.72,78.84 15.24,78.84 14.91,78.51 14.91,74.28 15.53,73.66 17.86,73.66 18.58,72.94 18.58,71.38 19.85,70.11 19.85,66.64 20.63,65.86 20.63,60.38 v1(20.41,60.16)
PMIC_NSLEEP: length 13.5
  TOP w0.14: U31.6 4.16,74.86 4.34,75.04 v1(4.93,75.04) ; U27.46 15.24,74.99 v1(15.31,74.91)
  BOTTOM w0.14: v1(4.93,75.04) 5.25,75.36 11.14,75.36 11.58,74.91 v1(15.31,74.91)
PMIC_OSC32KCAP: length 1.4
  TOP w0.305: U27.40 v1(12.16,77.54)
  BOTTOM w0.305: v1(12.16,77.54) 12.16,77.32 C381.1
PMIC_OSC32KIN: length 8.7
  TOP w0.132: 10.51,77.08 C85.2 ; 10.51,77.08 9.92,76.49 7.75,76.49 7.48,76.76 Y3.2 ; 10.51,77.08 10.51,76.62 10.64,76.49 10.88,76.49 11.12,76.73 11.12,77.94 11.72,78.54 U27.38
PMIC_OSC32KOUT: length 8.7
  TOP w0.132: Y3.1 7.48,75.73 7.86,76.11 9.92,76.11 10.51,75.52 ; U27.39 11.79,78.04 11.53,77.78 11.53,76.6 11.03,76.11 10.64,76.11 10.51,75.97 10.51,75.52 ; 10.51,75.52 C89.2
PMIC_POWERGOOD: length 97.1
  TOP w0.132: v1(15.24,83.17) U27.25
  TOP w0.14: TP81.1 v1(22.96,23.92)
  L03_SIG01 w0.102: v1(12.05,87.95) 12.05,85.26 10.12,83.33 10.12,80.88 10.12,76.59 10.12,76.03 10.31,75.84 10.31,75.83 12.76,73.39 12.76,58.88 15.61,56.03 15.61,51.66 17.59,49.68 17.59,40.9 18.14,40.36 18.14,39.98 21.04,37.08 21.04,34.7 22.45,33.29 22.45,24.99 22.96,24.47 v1(22.96,23.92)
  L05_SIG02 w0.102: v1(33.9,15.68) 33.08,14.86 30.72,14.86 27.14,18.44 25.37,18.44 23.32,20.49 23.32,23.56 v1(22.96,23.92)
  BOTTOM w0.14: R500.1 R501.1 23.37,24.32 v1(22.96,23.92) ; v1(12.05,87.95) 12.05,86.36 v1(15.24,83.17) ; v1(33.9,15.68) 33.9,15.7 33.72,15.89 U116.1
PMIC_WDOG_DISABLE: length 92.4
  TOP w0.14: U27.41 12.23,77.04 12.06,76.87 12.06,76.55 11.32,75.8 11.32,74.9 11.07,74.65 v1(10.67,74.65) ; TP74.1 60.4,30.05 60.4,28.93 61.04,28.28 v1(61.04,26.69)
  L05_SIG02 w0.102: v1(10.67,74.65) 10.67,74.6 10.67,74.6 10.67,67.82 10.91,67.58 10.91,61.33 17.52,54.73 20.56,54.73 20.89,54.4 22.48,54.4 23.46,53.42 28.43,53.42 29.16,52.69 32.37,52.69 41.73,43.34 41.73,40.65 42,40.38 42.33,40.38 46.11,36.6 46.11,36.03 47.54,34.6 49.77,34.6 50.33,34.04 53.75,34.04 55.17,32.63 55.52,32.63 56.26,31.89 58.12,31.89 60.55,29.46 60.55,28.43 61.04,27.94 v1(61.04,26.69)
  BOTTOM w0.14: R493.2 R492.2 62.66,26.04 62.01,26.69 v1(61.04,26.69)
PMIC_WDOG_TRIGG: length 52.5
  TOP w0.132: U18.D13 v1(33.08,105.26)
  TOP w0.14: v1(20.26,67.86) 20.26,67.67 R137.1
  L05_SIG02 w0.102: v1(33.08,105.26) 32.68,105.66 31.31,105.66 31.08,105.43 31.08,105.1 30.84,104.86 30.44,104.86 30.34,104.95 29.34,104.95 29.04,104.65 22.67,104.65 21.54,103.52 20.81,103.52 20.1,102.8 20.1,101.67 18.74,100.31 18.74,91.02 18.5,90.79 18.5,88.86 18.82,88.54 18.82,87.06 20.14,85.74 20.14,74.72 20.75,74.11 20.75,71.18 20.26,70.69 v1(20.26,67.86)
PORZ_OUT: length 182
  TOP w0.132: U18.F18 v1(34.68,109.26)
  TOP w0.14: v1(3.97,92.21) 3.97,92.7 R104.1 4.91,92.89 4.91,92.66 5.17,92.4 U24.6 ; v1(62.98,41.49) 62.98,42.06 63.17,42.25 U41.3 ; U42.3 63.42,38.77 v1(63.15,38.49) ; TP63.1 v1(58.47,46.24) R170.2
  L03_SIG01 w0.102: v1(17.64,40.07) 17.18,40.53 15.63,40.53 14.79,41.37 14.79,55.25 11.15,58.89 8.47,58.89 7.43,59.92 v1(5.63,59.92)
  L05_SIG02 w0.102: v1(58.47,46.24) 56.75,44.51 56.75,41.85 57.13,41.47 60.68,41.47 61.32,40.83 62.32,40.83 v1(62.98,41.49) 63.71,40.76 63.71,39.06 v1(63.15,38.49)
  L10_SIG03 w0.102: v1(5.63,59.92) 4.65,59.92 3.75,60.82 3.75,64.76 3.38,65.14 3.38,68.84 7.67,73.13 7.67,80.43 8.16,80.91 8.16,84.33 4.57,87.92 4.57,89.3 4.26,89.61 4.26,91.92 v1(3.97,92.21) ; v1(34.68,109.26) 34.6,109.26 34.2,109.66 33.71,109.66 33.48,109.9 33.48,110.3 33.32,110.47 32.9,110.47 32.68,110.68 32.68,111.1 32.51,111.26 31.12,111.26 31.12,111.26 30.47,110.61 26.29,110.61 25.12,109.44 24.31,109.44 24.09,109.65 22.75,109.65 v1(20.86,107.76) ; v1(58.47,46.24) 57.66,45.42 53.16,45.42 50.35,42.61 47.82,42.61 47.08,43.34 46.61,43.34 46.02,43.94 38.77,43.94 36.06,41.22 36.06,39.38 35.58,38.9 30.27,38.9 29.54,39.63 26.32,39.63 26.14,39.81 25.54,39.81 24.98,39.24 22.36,39.24 21.76,39.84 19.51,39.84 19.28,39.61 18.09,39.61 v1(17.64,40.07)
  BOTTOM w0.14: v1(20.86,107.76) 21.8,106.82 21.8,105.53 20.45,104.18 14.02,104.18 11.56,101.72 11.56,96.66 10.95,96.05 10.95,93.97 8.84,91.86 4.33,91.86 v1(3.97,92.21)
PP1_CABLE: length 1.6
  TOP w0.14: C117.1 v1(21.78,49.32)
  BOTTOM w0.14: v1(21.78,49.32) U90.25
PP2_CABLE: length 1.9
  BOTTOM w0.14: U90.46 21.78,40.81 R447.2
PR0_PRU0_GPO0: length 121.3
  TOP w0.132: U18.N21 v1(41.08,111.66)
  L10_SIG03 w0.102: v1(41.17,38.31) 40.84,38.64 40.84,39.82 41.08,40.07 44.58,40.07 45.94,38.71 47.69,38.71 48.63,39.65 51.1,39.65 52.04,38.71 53.5,38.71 54.15,38.06 57.64,38.06 58.18,38.61 59.32,38.61 60.35,39.65 61.21,39.65 61.71,40.15 61.71,40.9 61.45,41.16 61.45,43.63 62.92,45.1 62.92,51.37 63.38,51.83 63.38,52.52 64.87,54.01 64.87,57.45 64.87,57.65 66.09,58.86 66.09,62.37 64.24,64.22 59.52,64.22 55.4,68.35 55.4,69.52 50.95,73.96 50.95,82.19 49.54,83.6 49.54,89.81 51.51,91.78 51.51,93.64 49.09,96.07 48.11,96.07 47.88,96.3 47.88,96.63 47.65,96.86 47.32,96.86 47.31,96.87 47.08,97.1 47.08,97.11 47.08,97.43 46.85,97.67 46.8,97.67 46.8,97.67 46.51,97.67 46.28,97.9 46.28,98.23 46.05,98.47 45.71,98.47 45.48,98.7 45.48,99.03 45.25,99.26 44.91,99.26 44.68,99.5 44.68,99.89 44.5,100.07 39.91,100.07 39.39,100.58 39.39,110.19 39.69,110.49 39.69,111.84 39.91,112.06 40.68,112.06 v1(41.08,111.66)
  BOTTOM w0.14: v1(41.17,38.31) 41.03,38.45 RA5.8
PR0_PRU0_GPO1: length 116.7
  TOP w0.132: U18.N20 v1(41.08,110.86)
  L10_SIG03 w0.102: v1(41.08,110.86) U18.N20 40.06,110.47 39.63,110.03 39.63,101.31 40.07,100.86 44.45,100.86 44.68,100.63 44.68,100.34 44.68,100.3 44.91,100.07 45.25,100.07 45.48,99.83 45.48,99.5 45.71,99.27 46,99.27 46,99.26 46.05,99.26 46.28,99.03 46.28,98.64 46.46,98.47 46.85,98.47 47.08,98.23 47.08,98.22 47.08,97.9 47.31,97.67 47.65,97.67 47.88,97.43 47.88,97.1 48.11,96.87 48.64,96.87 51.74,93.77 51.74,91.66 49.77,89.69 49.77,83.72 51.18,82.31 51.18,74.05 55.62,69.61 55.62,68.44 59.61,64.45 64.33,64.45 66.32,62.47 66.32,58.76 65.1,57.54 65.1,52.69 63.17,50.76 63.17,44.95 62.31,44.08 62.31,39.86 60.76,38.31 58.27,38.31 57.61,37.66 54.23,37.66 53.41,38.48 51.29,38.48 50.98,38.78 48.24,38.78 47.92,38.46 43.04,38.46 v1(42.65,38.85)
  BOTTOM w0.14: RA5.7 v1(42.65,38.85)
PR0_PRU0_GPO2: length 119.2
  TOP w0.132: U18.N19 v1(41.08,110.06)
  L10_SIG03 w0.102: v1(41.08,110.06) 41.08,110 40.74,109.66 40.09,109.66 39.87,109.45 39.87,101.85 40.06,101.67 44.45,101.67 44.68,101.43 44.68,101.1 44.91,100.86 45.25,100.86 45.48,100.63 45.48,100.28 45.7,100.07 46.05,100.07 46.28,99.83 46.28,99.54 46.28,99.5 46.51,99.27 46.56,99.27 46.56,99.26 46.85,99.26 47.08,99.03 47.08,98.7 47.31,98.47 47.65,98.47 47.88,98.23 47.88,97.9 48.11,97.67 48.45,97.67 52,94.11 52,91.53 50,89.53 50,83.85 51.41,82.44 51.41,74.15 55.85,69.71 55.85,68.65 59.82,64.68 64.43,64.68 67.41,61.7 67.41,53.96 66.67,53.23 66.02,53.23 63.43,50.64 63.43,42.79 62.54,41.9 62.54,39.68 60.4,37.55 59.26,37.55 58.96,37.85 58.31,37.85 57.71,37.25 55.71,37.25 55.21,36.74 54.73,36.74 54.47,37.01 52.28,37.01 51.9,37.39 50.87,37.39 50.56,37.08 47.57,37.08 46.51,38.14 42.69,38.14 42.15,38.67 v1(42.15,39.65)
  BOTTOM w0.14: v1(42.15,39.65) 41.75,39.25 RA5.6
PR0_PRU0_GPO3: length 117.5
  TOP w0.132: U18.N18 v1(41.08,109.26)
  L10_SIG03 w0.102: v1(41.08,109.26) U18.N18 40.68,102.7 40.91,102.47 44.45,102.47 44.68,102.23 44.68,101.9 44.91,101.67 45.2,101.67 45.25,101.67 45.48,101.43 45.48,101.1 45.71,100.86 46.05,100.86 46.28,100.63 46.28,100.3 46.51,100.07 46.8,100.07 46.85,100.07 47.08,99.83 47.08,99.79 47.08,99.5 47.31,99.26 47.69,99.26 47.91,99.04 47.91,98.71 48.14,98.49 48.42,98.49 52.25,94.66 52.25,91.33 50.23,89.31 50.23,84.03 51.67,82.59 51.67,74.22 56.08,69.8 56.08,68.8 59.98,64.91 64.52,64.91 67.64,61.8 67.64,53.84 66.75,52.95 66.07,52.95 63.68,50.56 63.68,42.69 63.38,42.38 63.38,41.26 62.77,40.66 62.77,39.43 61.88,38.54 61.88,37.68 61.14,36.95 56.66,36.95 56.09,36.38 55.51,36.38 55.04,35.9 51.68,35.9 50.75,36.82 43.56,36.82 41.24,39.14 v1(41.24,39.65)
  BOTTOM w0.14: RA5.5 v1(41.24,39.65)
PR0_PRU0_GPO4: length 125.1
  TOP w0.132: U18.N17 v1(41.08,108.46)
  L10_SIG03 w0.102: v1(31.5,33.86) 32.82,35.18 60.39,35.18 63.53,38.32 63.53,39.03 63.76,39.26 63.76,40.96 64.24,41.44 64.24,45.35 66.04,47.16 66.04,51.14 67.87,52.97 67.87,61.89 64.62,65.14 60.07,65.14 56.31,68.9 56.31,69.9 51.93,74.27 51.93,82.73 50.48,84.18 50.48,89.1 52.5,91.12 52.5,94.92 47.91,99.51 47.91,99.8 47.65,100.07 47.3,100.07 47.08,100.28 47.08,100.71 46.93,100.86 46.55,100.86 46.55,100.87 46.51,100.87 46.28,101.1 46.28,101.41 46.28,101.43 46.05,101.67 45.65,101.67 45.48,101.83 45.48,102.31 45.33,102.47 44.91,102.47 44.68,102.7 44.68,103.03 44.42,103.29 42.09,103.29 41.48,103.9 41.48,107.83 41.25,108.06 41.25,108.29 v1(41.08,108.46)
  BOTTOM w0.14: v1(31.5,33.86) 31.78,33.58 RA6.5
PR0_PRU0_GPO5: length 125.9
  TOP w0.132: U18.P18 v1(41.88,109.26)
  L10_SIG03 w0.102: v1(41.88,109.26) U18.P18 41.48,108.3 41.71,108.07 42.12,108.07 42.28,107.9 42.28,103.96 42.73,103.52 45.01,103.52 45.48,103.05 45.48,102.7 45.71,102.47 46.17,102.47 46.28,102.35 46.28,101.9 46.51,101.67 46.97,101.67 47.08,101.55 47.08,101.1 47.31,100.87 47.64,100.87 47.65,100.86 47.88,100.63 47.88,100.34 48.24,99.98 48.24,99.69 52.75,95.17 52.75,91.02 50.73,88.99 50.73,84.29 52.2,82.81 52.2,74.33 57.89,68.64 57.89,67.78 60.3,65.37 64.75,65.37 68.73,61.38 68.73,54.62 68.15,54.04 68.15,52.92 66.3,51.07 66.3,47 64.49,45.2 64.49,41.26 64.06,40.83 64.06,39.15 63.78,38.87 63.78,38.22 60.48,34.91 33.37,34.91 v1(32.34,33.89)
  BOTTOM w0.14: RA6.6 32.18,33.73 v1(32.34,33.89)
PR0_PRU0_GPO6: length 125.5
  TOP w0.132: U18.P19 v1(41.88,110.07)
  L10_SIG03 w0.102: v1(33.53,33.8) 34.42,34.68 60.68,34.68 63.78,37.78 64.32,37.78 64.72,38.18 64.72,40.03 65.36,40.67 65.36,45.66 66.58,46.88 66.58,50.99 68.43,52.85 68.43,53.91 68.99,54.47 68.99,61.45 64.84,65.6 60.43,65.6 58.17,67.86 58.17,68.69 52.43,74.43 52.43,82.91 50.96,84.38 50.96,88.9 52.98,90.93 52.98,95.32 48.54,99.76 48.54,100.39 47.88,101.05 47.88,101.51 47.73,101.67 47.31,101.67 47.08,101.9 47.08,102.23 46.85,102.47 46.51,102.47 46.28,102.7 46.28,103.03 45.99,103.32 45.6,103.32 44.68,104.25 44.68,104.63 44.45,104.86 44.08,104.86 43.88,105.07 43.88,105.45 43.66,105.66 43.3,105.66 43.08,105.89 43.08,107.83 42.85,108.06 42.51,108.06 42.28,108.3 42.28,109.48 42.04,109.72 42.04,109.91 v1(41.88,110.07)
  BOTTOM w0.14: RA6.7 32.58,33.38 32.72,33.52 33.25,33.52 v1(33.53,33.8)
PR0_PRU0_GPO7: length 128
  TOP w0.132: U18.P21 v1(41.88,111.66)
  L10_SIG03 w0.102: v1(41.88,111.66) U18.P21 41.48,110.7 41.71,110.47 42.07,110.47 42.28,110.25 42.28,109.9 42.51,109.67 42.9,109.67 43.08,109.49 43.08,108.22 43.23,108.07 43.74,108.07 43.88,107.93 43.88,105.88 44.1,105.66 44.45,105.66 44.68,105.43 44.68,105.07 44.89,104.86 45.28,104.86 45.48,104.67 45.48,104.17 46.34,103.31 46.82,103.31 47.08,103.05 47.08,102.7 47.31,102.47 47.74,102.47 47.91,102.3 47.91,101.77 48.08,101.6 48.08,101.23 49.08,100.24 49.22,100.24 49.63,99.83 49.63,99.08 53.21,95.5 53.21,90.83 51.18,88.8 51.18,84.48 52.69,82.97 52.69,74.49 58.43,68.75 58.43,67.95 60.56,65.83 64.94,65.83 69.24,61.52 69.24,54.32 68.71,53.79 68.71,52.74 66.8,50.84 66.8,46.75 65.66,45.6 65.66,38.26 61.8,34.41 40.78,34.41 40.07,33.7 34.25,33.7 v1(33.54,32.99)
  BOTTOM w0.14: RA6.8 v1(33.54,32.99)
REFCLK1_R: length 5.4
  TOP w0.14: U18.A20 28.73,110.47 26.6,112.6 R55.2
RES_LM5141: length 2.2
  BOTTOM w0.14: C427.1 31.87,42.78 32.08,42.99 32.67,42.99 33.03,43.35 U89.24
RESETSTATZ: length 281.6
  TOP w0.132: U18.F19 v1(34.68,110.06)
  TOP w0.14: U2.28 50.51,153.58 v1(51.01,154.08) ; R171.2 v1(61.13,45.5) 61.45,45.17 63.09,45.17 TP65.1 63.72,44.55 R173.1 64.38,44.83 64.57,45.02 65.38,45.02 66.53,43.88 66.53,41.77 R178.1 ; U5.3 v1(43.42,145.66) ; v1(8.43,92.27) 8.04,91.88 6.75,91.88 6.64,91.77 U24.3 ; U11.2 v1(41.66,124.33) ; U32.2 v1(61.06,70.07)
  L03_SIG01 w0.102: v1(46.59,42.86) 46.59,42.01 47.51,41.09 49.07,41.09 50.53,39.62 53.24,39.62 53.84,39.02 54.56,39.02 v1(55.11,38.47) ; v1(43.42,145.66) 45.51,145.66 47.04,147.19 47.04,150.96 49.69,153.61 50.53,153.61 v1(51.01,154.08)
  L05_SIG02 w0.102: v1(59.24,71.89) 59.24,73.13 63.47,77.37 63.47,79.79 62.72,80.55 62.72,84.44 62.31,84.85 62.31,86.07 60.86,87.52 60.48,87.52 59.57,88.43 59.57,90.84 59.34,91.07 59.34,97.55 59.67,97.88 59.67,99.76 60.05,100.14 60.05,105.63 58.24,107.43 58.24,108.98 56.67,110.55 v1(55.53,110.55) ; v1(61.06,70.07) 60.58,69.58 60.58,67.04 60.1,66.56 60.1,47.66 61.13,46.64 v1(61.13,45.5) ; v1(17.06,114.52) 16.43,114.52 16.05,114.14 16.05,113.49 11.81,109.25 11.81,108.46 9.04,105.69 9.04,100.22 9.27,99.99 9.27,97.63 8.98,97.33 8.98,95.21 8.88,95.12 8.88,93.31 8.43,92.86 v1(8.43,92.27)
  L10_SIG03 w0.102: v1(55.53,110.55) 55.2,110.88 55.2,112.05 54.66,112.59 54.66,116.66 50.45,120.87 49.51,120.87 47.47,122.91 46.05,122.91 45.2,123.76 44.07,123.76 43.86,123.97 42.02,123.97 v1(41.66,124.33) 40.28,125.71 32.73,125.71 32.31,126.12 26.65,126.12 25.73,125.2 25.72,125.2 25.66,125.13 21.9,125.13 17.93,121.17 17.93,116.73 17.25,116.05 17.25,114.71 v1(17.06,114.52) 17.25,114.33 17.25,113.49 17.7,113.05 17.7,112.62 18.26,112.06 18.6,112.06 19.2,111.45 19.2,111.1 19.72,110.58 24.45,110.58 24.7,110.83 25.56,110.83 25.89,111.16 26.37,111.16 27.51,112.31 27.51,114.7 28.39,115.59 31.64,115.59 34.28,112.95 34.28,110.46 v1(34.68,110.06) ; v1(43.42,145.66) 46.82,145.66 47.4,146.24 49.3,146.24 51.68,143.87 51.68,141.34 50.18,139.85 49.79,139.85 48.69,138.75 47.09,138.75 45.75,137.4 44.92,137.4 43.17,135.66 v1(43.17,135.41) ; v1(59.24,71.89) v1(61.06,70.07) ; v1(61.13,45.5) 61.13,41.05 61.42,40.76 61.42,40.22 61.2,40 58.74,40 58.07,39.33 57.25,39.33 56.4,38.47 v1(55.11,38.47)
  BOTTOM w0.14: U93.2 61.21,42.88 R430.1 60.93,44.13 60.72,44.34 60.72,45.1 v1(61.13,45.5) ; v1(43.17,135.41) 43.17,135.37 43.94,134.6 43.94,132.31 43.67,132.03 43.67,126.33 v1(41.66,124.33) ; U94.2 45.95,41.31 46.59,41.95 v1(46.59,42.86) ; U92.28 54.7,38.88 v1(55.11,38.47)
RGMII2_BRD_CONN_DET: length 48
  TOP w0.14: J4.43 R571.1 61.98,121.28 v1(62.59,120.67) ; U2.19 v1(53.61,149.06)
  L03_SIG01 w0.102: v1(48.66,145.28) 49.83,145.28 v1(53.61,149.06)
  L05_SIG02 w0.102: v1(48.66,145.28) 48.42,145.04 48.42,143.63 46.95,142.16 46.95,139.79 45.75,138.58 45.75,137.81 46.19,137.37 53.4,137.37 59.06,131.71 59.06,127.42 62.59,123.89 v1(62.59,120.67)
RGMII2_RSTN: length 94.9
  TOP w0.14: v1(57.27,115.08) 57.07,114.88 J4.12 ; v1(64.33,38.34) U42.4
  L05_SIG02 w0.102: v1(60.92,115.08) 61.14,114.86 61.14,107.56 61.32,107.38 61.32,103.93 61.93,103.32 61.93,102.4 61.37,101.84 61.37,100.27 61.7,99.94 61.7,97.73 61.57,97.6 61.57,92.17 61.09,91.69 61.09,89.9 63.81,87.19 63.81,80.17 63.96,80.02 63.96,77.13 60.12,73.3 60.12,67.12 59.79,66.79 59.79,50.89 55.53,46.62 55.53,45.48 56.42,44.59 56.42,41.54 57.36,40.6 60.19,40.6 62.71,38.09 64.08,38.09 v1(64.33,38.34)
  L10_SIG03 w0.102: v1(60.92,115.08) 60.52,115.48 57.68,115.48 v1(57.27,115.08)
  BOTTOM w0.14: v1(57.27,115.08) R314.1
RMII_CLOCK: length 69.7
  TOP w0.14: v1(15.12,110.21) 15.65,110.75 21.15,110.75 21.33,110.57 R58.1 ; v1(58.47,120.68) 58.67,120.48 J4.39
  L10_SIG03 w0.102: v1(58.47,120.68) 58.07,121.07 55.72,121.07 54.39,122.4 54.39,122.63 51.64,125.38 47.61,125.38 46.95,126.04 32.98,126.04 32.48,126.54 26.75,126.54 25.63,125.43 19.38,125.43 19.19,125.62 16.25,125.62 15.46,124.83 15.46,123.83 14.89,123.25 14.89,121.3 15.12,121.08 v1(15.12,110.21)
  BOTTOM w0.14: R307.2 v1(58.47,120.68)
RT_LM5141: length 1.7
  BOTTOM w0.14: R423.1 30.71,45.86 U89.4
SEL_XDS: length 42.7
  L03_SIG01 w0.102: v1(55.72,21.72) 52.17,21.72 51.5,21.06 46.97,21.06 v1(46.63,21.4) ; v1(65.67,18.72) 65.18,18.24 63.32,18.24 63.02,18.54 63.02,21.69 63.48,22.15 63.48,22.76 65.23,24.51 65.48,24.51 66.74,25.77 v1(67.34,25.77)
  L05_SIG02 w0.102: v1(65.67,18.72) 65.12,19.28 64.4,19.28 63.58,20.09 61.73,20.09 61,20.82 60.17,20.82 60.08,20.73 56.71,20.73 v1(55.72,21.72)
  BOTTOM w0.14: v1(55.72,21.72) 57.04,21.72 57.29,21.47 U109.4 ; U111.1 65.96,19.73 65.67,19.44 v1(65.67,18.72) 66.16,18.72 66.34,18.9 U111.16 ; U103.4 67.55,25.86 67.46,25.77 v1(67.34,25.77) ; U106.5 48.28,24.5 48.14,24.36 48.14,24.09 47.01,22.96 47.01,21.78 v1(46.63,21.4)
SEL_XDS110_INV: length 72.1
  TOP w0.14: J19.8 v1(39.89,6.34)
  L03_SIG01 w0.102: v1(69.78,23.61) 68.99,22.82 68.84,22.82 65.31,19.29 64.23,19.29 v1(63.64,18.7) ; v1(43.39,16.09) 44.73,16.09 45.58,16.94 45.58,19.36 46.78,20.56 v1(47.25,20.56)
  L05_SIG02 w0.102: v1(39.89,6.34) 39.89,10.57 40.46,11.14 40.46,13.17 v1(43.39,16.09) 43.94,15.53 49.2,15.53 50,16.33 50.9,16.33 51.96,15.28 53.33,15.28 53.94,15.89 59.35,15.89 60.14,16.68 61.25,16.68 63.28,18.7 v1(63.64,18.7) ; v1(44.97,24.83) 47.84,21.95 47.84,21.15 v1(47.25,20.56)
  BOTTOM w0.14: v1(44.97,24.83) 44.97,24.35 45.12,24.21 U107.2 ; v1(39.89,6.34) 39.89,7.26 40.33,7.7 U122.4 ; U112.5 63.51,18.84 v1(63.64,18.7) ; U117.2 42.79,15.49 v1(43.39,16.09) ; v1(69.78,23.61) 69.78,24.68 70.01,24.91 R498.1 R497.2 71.26,25.28 71.4,25.42 71.4,26.28 71.17,26.51 U103.2 ; U114.16 47.22,19.89 47.03,20.08 47.03,20.34 v1(47.25,20.56) 48,20.56 48.26,20.3 U114.1
SLOW_CLK: length 15.7
  TOP w0.14: J2.50 v1(11.42,146.79)
  L03_SIG01 w0.102: v1(11.42,146.79) 18.53,139.68 18.53,137.11 v1(19.43,136.21)
  BOTTOM w0.14: R280.2 v1(19.43,136.21)
SOC_CLKIN: length 49.6
  TOP w0.14: R35.2 C19.1 R36.2 34.36,134.83 34.19,134.66 v1(33.79,134.66) ; R69.1 26.93,105.64 27.54,106.26 v1(27.54,107.13)
  BOTTOM w0.14: v1(27.54,107.13) 27.54,114.75 30.81,118.02 30.81,133.14 32.33,134.66 v1(33.79,134.66)
SOC_DVDD1V8: length 52.6
  TOP w0.279: U27.37 v1(12.09,79.04)
  TOP w0.305: v1(24.86,108.95) 24.86,108.55 C528.1 ; v1(26.71,108.95) 26.71,108.55 C528.3 26.58,107.75 v1(26.7,107.63) 26.58,107.51 C32.1
  TOP w0.356: U18.T8 v1(43.48,100.47) ; U18.H16 v1(36.28,107.66) ; U18.L16 v1(38.68,107.66) ; U18.K15 v1(37.88,106.86) ; U18.U8 v1(44.28,100.47) ; U18.F12 v1(34.68,104.46) ; U18.H17 v1(36.28,108.46)
  L03_SIG01 w0.14: v1(34.68,104.46) 34.28,104.86 31.05,104.86 30.81,104.62 29.1,104.62 27.03,102.55 26.49,102.55 23.56,99.63 23.56,98.47 22.16,97.08 21.78,97.08 21.29,96.58 21.29,87.96 19.93,86.6 16.55,86.6 13.13,83.19 13.13,80.03 12.14,79.04 v1(12.09,79.04)
  BOTTOM w0.254: C218.1 39.09,108.17 C225.1 ; v1(26.71,108.95) 26.61,108.95 C529.1 ; v1(24.86,108.95) 24.95,108.95 C529.3
  BOTTOM w0.305: 43.65,100.6 43.62,100.6 v1(43.48,100.47) ; C217.1 36.3,108.48 v1(36.28,108.46) ; 44.48,100.26 v1(44.28,100.47) ; C258.1 34.68,104.06 v1(34.68,104.46) ; C225.1 38.69,107.66 v1(38.68,107.66) ; v1(36.28,107.66) 36.08,107.87 C221.1
  vias: v1(3.28,88.99) v1(3.28,88.07) v1(4.15,88.99) v1(4.15,88.07) v1(5.01,88.99) v1(5.01,88.07) v1(28.4,78.17) v1(28.4,77.26)
SOC_DVDD3V3: length 58.3
  TOP w0.305: C522.1 18.51,102.34 v1(18.35,102.19) ; C522.3 v1(20.74,102.91) ; U27.49 v1(16.74,74.91) ; C41.1 v1(20.32,101.33)
  TOP w0.356: U18.U13 v1(44.28,105.26) ; U18.G11 v1(35.48,102.87) ; U18.U10 v1(44.28,102.07) ; U18.G14 v1(35.48,106.06) ; U18.R13 v1(42.68,105.26) ; U18.N15 v1(41.08,106.86) ; U18.H13 v1(36.28,105.26) ; U18.M15 v1(40.28,106.86) ; U18.L15 v1(38.68,106.86) ; U18.H10 v1(36.28,102.07) ; U18.F9 v1(34.68,101.27) ; U18.T13 v1(43.48,105.26)
  L03_SIG01 w0.14: v1(35.48,102.87) 35.06,103.29 31.28,103.29 30.56,102.57 30.35,102.57 29.03,101.26 28,101.26 26.91,100.18 26.91,99.63 25.76,98.49 25.76,94.91 24.31,93.45 24.31,88.3 19.97,83.96 19.97,77.15 19.71,76.9 17.48,76.9 16.74,76.16 v1(16.74,74.91)
  L07_PWR02 w0.165: 43.8,102.47 43.17,102.47
  L07_PWR02 w0.406: v1(38.68,106.86) v1(40.28,106.86) ; v1(36.28,105.26) v1(35.48,106.06)
  BOTTOM w0.305: v1(34.68,101.27) 34.68,101.51 C276.1 ; C239.1 42.8,105.39 v1(42.68,105.26) ; C229.1 41.2,106.99 v1(41.08,106.86) ; v1(36.28,102.07) 36.39,102.17 C523.3 ; v1(40.28,106.86) 40.24,106.82 C232.1 ; C257.1 35.26,103.09 v1(35.48,102.87) 35.59,102.97 35.68,102.97 ; C270.1 44.47,101.88 v1(44.28,102.07) ; C244.1 v1(43.48,105.26) ; C238.1 44.4,105.39 v1(44.28,105.26) ; C233.1 38.72,106.82 v1(38.68,106.86) ; C240.1 v1(35.48,106.06) ; C247.1 v1(36.28,105.26)
  vias: v1(12.55,99.94) v1(12.55,99.28) v1(13.36,99.94) v1(13.36,99.03) v1(14.28,99.94) v1(14.28,99.03)
SOC_EMU0: length 156.6
  TOP w0.132: U18.C13 v1(32.28,105.26)
  TOP w0.14: v1(55.43,23.69) 54.54,24.57 52.41,24.57 51.15,23.31 R224.2 v1(49.34,22.65)
  L03_SIG01 w0.102: v1(49.34,22.65) 48.48,23.51 44.48,23.51 39.73,18.76 37.74,18.76 36.5,17.52 32.91,17.52 31.71,18.72 31.71,22.27 34.44,25.01 34.44,26.05 34.8,26.4 34.8,30.52 35.79,31.51 35.79,34.68 36.76,35.65 36.76,36.51 38.08,37.83 38.08,40.15 39.42,41.49 39.42,45.73 37.85,47.3 37.85,60.3 37.1,61.05 32.13,61.05 v1(31.7,60.62)
  L05_SIG02 w0.102: v1(31.7,60.62) 31.52,60.44 22.21,60.44 21.49,61.16 20.87,61.78 20.87,65.77 21.24,66.13 21.24,70.46 21.59,70.81 21.59,74.69 20.98,75.3 20.98,88.79 20.43,89.34 20.43,95.06 21.35,95.98 21.35,100.83 22.13,101.6 22.13,102.11 23.79,103.78 28.82,103.78 29.11,103.49 30.59,103.49 31.07,103.96 31.67,103.96 31.88,104.17 31.88,104.86 v1(32.28,105.26)
  BOTTOM w0.14: U106.2 v1(49.34,22.65) ; v1(55.43,23.69) 56.3,22.82 57.29,22.82 58.06,22.05 60.51,22.05 61.13,21.43 62.07,21.43 62.81,20.7 U112.2
SOC_EMU1: length 146
  TOP w0.132: U18.E10 v1(33.88,102.07)
  TOP w0.14: v1(55.31,24.58) 54.95,24.94 48.24,24.94 47.98,24.69 47.98,23.58 48.14,23.42 48.32,23.42 R223.2 48.42,22.88 48.41,22.88 v1(48.41,22.8)
  L03_SIG01 w0.102: v1(48.41,22.8) 47.71,22.1 46.63,22.1 46.04,21.51 42.92,21.51 39.86,18.46 37.89,18.46 36.71,17.27 31.92,17.27 31.31,17.88 31.31,22.33 33.89,24.91 33.89,30.44 34.95,31.51 34.95,33.47 35.38,33.9 35.38,34.86 36.43,35.9 36.43,36.69 37.65,37.91 37.65,40.35 38.41,41.11 38.41,45.28 37.51,46.18 37.51,60.18 36.91,60.78 34,60.78 v1(33.78,60.57)
  L05_SIG02 w0.102: v1(33.78,60.57) 33.48,60.87 33.48,62.8 32.64,63.64 29.06,63.64 28.4,64.3 28.4,65.57 28.12,65.85 28.12,69.56 24.24,73.43 24.24,91.69 24.41,91.86 24.41,94.91 25.64,96.14 25.64,98.42 27.09,99.86 28.84,99.86 29.67,100.69 30.35,100.69 30.53,100.87 32.48,100.87 32.68,101.06 32.68,101.44 32.9,101.66 33.48,101.66 v1(33.88,102.07)
  BOTTOM w0.14: U112.3 63.16,21.11 62.42,21.84 61.28,21.84 60.77,22.35 60.77,23.26 60.17,23.87 56.03,23.87 v1(55.31,24.58) ; U106.3 48.99,23.12 48.67,22.8 v1(48.41,22.8)
SOC_GPIO1_49: length 22.6
  TOP w0.132: U18.D18 v1(33.08,109.26)
  L03_SIG01 w0.102: v1(17.35,106.85) 17.35,105.36 18.05,104.66 25.4,104.66 27.15,106.41 27.97,106.41 30.42,108.86 32.68,108.86 v1(33.08,109.26)
  BOTTOM w0.14: R323.1 19.15,107.18 18.77,106.81 R324.2 17.79,106.81 17.75,106.85 v1(17.35,106.85)
SOC_I2C0_SCL: length 195.4
  TOP w0.132: U38.6 v1(22.05,52.99) ; U18.D17 v1(33.08,108.46)
  TOP w0.14: v1(41.63,133.44) 41.99,133.09 41.99,132.46 42.25,132.2 J3.28 ; J4.42 55.92,120.88 55.43,121.37 53.54,121.37 v1(53.29,121.12)
  L03_SIG01 w0.102: v1(53.29,121.12) 52.69,121.71 52.69,125.02 50.9,126.81 44.32,126.81 43.5,127.62 43.5,129.49 J3.28 ; v1(9.25,86.63) 8.85,87.03 8.85,91.09 10.16,92.41 10.51,92.41 10.52,92.42 14.36,92.42 15.52,93.59 15.52,95.64 11.95,99.22 11.95,102.05 12.99,103.09 v1(12.99,104.43) ; v1(14.18,68.19) 13.24,67.25 13.24,59.17 19.1,53.3 21.73,53.3 v1(22.05,52.99)
  L10_SIG03 w0.102: v1(14.18,68.19) 13.21,69.16 13.21,82.41 10.59,85.03 9.25,85.03 8.81,85.47 8.81,86.19 v1(9.25,86.63) ; v1(33.08,108.46) 33.48,108.06 33.48,107.5 33.25,107.26 33.22,107.26 32.91,107.26 32.68,107.03 32.68,106.99 32.68,106.7 32.45,106.47 32.03,106.47 31.88,106.31 31.88,105.9 31.65,105.67 31.26,105.67 31.08,105.49 31.08,105.1 30.83,104.85 26.9,104.85 25.75,103.7 23.33,103.7 22.11,102.48 20.23,102.48 19.75,102.96 14.45,102.96 v1(12.99,104.43) 12.99,104.81 10.49,107.3 10.49,110.32 9.41,111.4 9.41,111.4 9.04,111.77 9.04,120.82 10.89,122.66 10.89,124.34 13.7,127.15 15.05,127.15 15.73,127.83 15.73,131.46 16.51,132.25 18.09,132.25 18.82,132.98 18.82,133.82 19,134 23.07,134 24.08,132.98 33.72,132.98 34.93,134.2 40.87,134.2 v1(41.63,133.44)
  BOTTOM w0.14: R421.1 26.04,47.13 26.27,47.36 26.27,48.76 26.14,48.88 26.14,50.13 24.01,52.26 24.01,52.97 23.5,53.48 22.81,53.48 22.6,53.27 R408.2 v1(22.05,52.99) ; v1(9.25,86.63) 10.14,86.63 12.79,83.98 R363.1
SOC_I2C0_SCL_PMIC: length 18.7
  TOP w0.132: U27.31 12.18,82.04 12.12,82.11 v1(12.09,82.11)
  TOP w0.14: v1(14.32,66.87) 14.32,66.87 TP43.1
  L10_SIG03 w0.102: v1(12.09,82.11) 12.71,81.49 12.71,68.48 v1(14.32,66.87)
  BOTTOM w0.14: R363.2 12.38,81.85 12.12,82.11 v1(12.09,82.11)
